$ Spice netlist generated by v2lvs
$ v2021.1_33.19    Mon Mar 1 16:09:52 PST 2021

.INCLUDE "/proj/cad/library/asap7/asap7sc7p5t_27/CDL/LVS/asap7sc7p5t_27_L.cdl"
.INCLUDE "/proj/cad/library/asap7/asap7sc7p5t_27/CDL/LVS/asap7sc7p5t_27_R.cdl"
.INCLUDE "/proj/cad/library/asap7/asap7sc7p5t_27/CDL/LVS/asap7sc7p5t_27_SL.cdl"
.INCLUDE "/proj/cad/library/asap7/asap7sc7p5t_27/CDL/LVS/asap7sc7p5t_27_SRAM.cdl"
.INCLUDE “/home/013/o/om/oma190007/cad/msdap_new/SRAM.cdl"

*.BUSDELIMITER [

.SUBCKT CO_MEM write_enable read_enable Sclk Frame Write_Address[8]
+ Write_Address[7] Write_Address[6] Write_Address[5] Write_Address[4]
+ Write_Address[3] Write_Address[2] Write_Address[1] Write_Address[0]
+ Read_Address[8] Read_Address[7] Read_Address[6] Read_Address[5]
+ Read_Address[4] Read_Address[3] Read_Address[2] Read_Address[1]
+ Read_Address[0] data_in[15] data_in[14] data_in[13] data_in[12] data_in[11]
+ data_in[10] data_in[9] data_in[8] data_in[7] data_in[6] data_in[5] data_in[4]
+ data_in[3] data_in[2] data_in[1] data_in[0] Coeff[15] Coeff[14] Coeff[13]
+ Coeff[12] Coeff[11] Coeff[10] Coeff[9] Coeff[8] Coeff[7] Coeff[6] Coeff[5]
+ Coeff[4] Coeff[3] Coeff[2] Coeff[1] Coeff[0]
*.CONNECT Coeff[9] VSS
*.CONNECT Coeff[10] VSS
*.CONNECT Coeff[11] VSS
*.CONNECT Coeff[12] VSS
*.CONNECT Coeff[13] VSS
*.CONNECT Coeff[14] VSS
*.CONNECT Coeff[15] VSS
Xmem_0_0 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_0_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_0_O[11] O[10]=mem_0_O[10] O[9]=mem_0_O[9] O[8]=mem_0_O[8]
+ O[7]=mem_0_O[7] O[6]=mem_0_O[6] O[5]=mem_0_O[5] O[4]=mem_0_O[4] O[3]=mem_0_O[3]
+ O[2]=mem_0_O[2] O[1]=mem_0_O[1] O[0]=mem_0_O[0]
Xmem_0_1 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_1_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_1_O[11] O[10]=mem_1_O[10] O[9]=mem_1_O[9] O[8]=mem_1_O[8]
+ O[7]=mem_1_O[7] O[6]=mem_1_O[6] O[5]=mem_1_O[5] O[4]=mem_1_O[4] O[3]=mem_1_O[3]
+ O[2]=mem_1_O[2] O[1]=mem_1_O[1] O[0]=mem_1_O[0]
Xmem_0_2 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_2_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_2_O[11] O[10]=mem_2_O[10] O[9]=mem_2_O[9] O[8]=mem_2_O[8]
+ O[7]=mem_2_O[7] O[6]=mem_2_O[6] O[5]=mem_2_O[5] O[4]=mem_2_O[4] O[3]=mem_2_O[3]
+ O[2]=mem_2_O[2] O[1]=mem_2_O[1] O[0]=mem_2_O[0]
Xmem_0_3 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_3_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_3_O[11] O[10]=mem_3_O[10] O[9]=mem_3_O[9] O[8]=mem_3_O[8]
+ O[7]=mem_3_O[7] O[6]=mem_3_O[6] O[5]=mem_3_O[5] O[4]=mem_3_O[4] O[3]=mem_3_O[3]
+ O[2]=mem_3_O[2] O[1]=mem_3_O[1] O[0]=mem_3_O[0]
XRW0_rdata_reg[5] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_38 Q=Coeff[5]
XRW0_rdata_reg[7] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_32 Q=Coeff[7]
XRW0_rdata_reg[8] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_33 Q=Coeff[8]
XRW0_rdata_reg[1] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_31 Q=Coeff[1]
XRW0_rdata_reg[6] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_35 Q=Coeff[6]
XRW0_rdata_reg[4] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_37 Q=Coeff[4]
XRW0_rdata_reg[0] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_34 Q=Coeff[0]
XRW0_rdata_reg[3] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_36 Q=Coeff[3]
XRW0_rdata_reg[2] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_30 Q=Coeff[2]
Xg682__2398 NAND2xp33_ASAP7_75t_SL $PINS A=n_23 B=n_24 Y=n_38
Xg683__5107 NAND2xp33_ASAP7_75t_SL $PINS A=n_25 B=n_26 Y=n_37
Xg684__6260 NAND2xp33_ASAP7_75t_SL $PINS A=n_27 B=n_28 Y=n_36
Xg685__4319 NAND2xp33_ASAP7_75t_SL $PINS A=n_29 B=n_22 Y=n_35
Xg686__8428 NAND2xp33_ASAP7_75t_SL $PINS A=n_15 B=n_16 Y=n_34
Xg687__5526 NAND2xp33_ASAP7_75t_SL $PINS A=n_17 B=n_18 Y=n_33
Xg688__6783 NAND2xp33_ASAP7_75t_SL $PINS A=n_19 B=n_12 Y=n_32
Xg689__3680 NAND2xp33_ASAP7_75t_SL $PINS A=n_13 B=n_14 Y=n_31
Xg690__1617 NAND2xp33_ASAP7_75t_SL $PINS A=n_21 B=n_20 Y=n_30
Xg691__2802 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[6] A2=n_8 B1=n_10
+ B2=mem_1_O[6] Y=n_29
Xg692__1705 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[3] A2=n_11 B1=n_9
+ B2=mem_3_O[3] Y=n_28
Xg693__5122 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[3] A2=n_8 B1=n_10
+ B2=mem_1_O[3] Y=n_27
Xg694__8246 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[4] A2=n_11 B1=n_9
+ B2=mem_3_O[4] Y=n_26
Xg695__7098 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[4] A2=n_8 B1=n_10
+ B2=mem_1_O[4] Y=n_25
Xg696__6131 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[5] A2=n_11 B1=n_9
+ B2=mem_3_O[5] Y=n_24
Xg697__1881 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[5] A2=n_8 B1=n_10
+ B2=mem_1_O[5] Y=n_23
Xg698__5115 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[6] A2=n_11 B1=n_9
+ B2=mem_3_O[6] Y=n_22
Xg699__7482 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[2] A2=n_8 B1=n_10
+ B2=mem_1_O[2] Y=n_21
Xg700__4733 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[2] A2=n_11 B1=n_9
+ B2=mem_3_O[2] Y=n_20
Xg701__6161 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[7] A2=n_8 B1=n_10
+ B2=mem_1_O[7] Y=n_19
Xg702__9315 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[8] A2=n_11 B1=n_9
+ B2=mem_3_O[8] Y=n_18
Xg703__9945 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[8] A2=n_8 B1=n_10
+ B2=mem_1_O[8] Y=n_17
Xg704__2883 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[0] A2=n_11 B1=n_9
+ B2=mem_3_O[0] Y=n_16
Xg705__2346 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[0] A2=n_8 B1=n_10
+ B2=mem_1_O[0] Y=n_15
Xg706__1666 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[1] A2=n_11 B1=n_9
+ B2=mem_3_O[1] Y=n_14
Xg707__7410 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[1] A2=n_8 B1=n_10
+ B2=mem_1_O[1] Y=n_13
Xg708__6417 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[7] A2=n_11 B1=n_9
+ B2=mem_3_O[7] Y=n_12
Xg709__5477 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[0] B=n_6 Y=n_11
Xg710__2398 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[1] B=n_7 Y=n_10
Xg711__5107 NOR2xp33_ASAP7_75t_SL $PINS A=n_7 B=n_6 Y=n_9
Xg712__6260 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[0] B=cs_vec[1] Y=n_8
Xg713 INVx1_ASAP7_75t_SL $PINS A=cs_vec[0] Y=n_7
Xg714 INVx1_ASAP7_75t_SL $PINS A=cs_vec[1] Y=n_6
Xg715__4319 OR2x2_ASAP7_75t_SRAM $PINS A=n_3 B=n_5 Y=mem_3_CSB
Xcs_vec_reg[0] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_3 QN=cs_vec[0]
Xcs_vec_reg[1] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_5 QN=cs_vec[1]
Xg718__8428 NAND2xp33_ASAP7_75t_SL $PINS A=n_5 B=n_3 Y=mem_0_CSB
Xg719__5526 NAND2xp33_ASAP7_75t_SL $PINS A=n_2 B=n_5 Y=mem_1_CSB
Xg720__6783 NAND2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_3 Y=mem_2_CSB
Xg721 INVxp67_ASAP7_75t_SL $PINS A=n_5 Y=n_4
Xg722__3680 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg723__1617 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[4] A2=n_0
+ B1=Write_Address[4] B2=write_enable Y=RW0_addr[4]
Xg724__2802 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[5] A2=n_0
+ B1=Write_Address[5] B2=write_enable Y=RW0_addr[5]
Xg725__1705 AOI22xp5_ASAP7_75t_SL $PINS A1=Read_Address[8] A2=n_0
+ B1=Write_Address[8] B2=write_enable Y=n_5
Xg726__5122 OA21x2_ASAP7_75t_L $PINS A1=Frame A2=n_0 B=n_1 Y=mem_OEB
Xg727 INVxp67_ASAP7_75t_SL $PINS A=n_3 Y=n_2
Xg728__8246 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg729__7098 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[6] A2=n_0
+ B1=Write_Address[6] B2=write_enable Y=RW0_addr[6]
Xg730__6131 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg731__1881 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg732__5115 AOI22xp5_ASAP7_75t_SL $PINS A1=Read_Address[7] A2=n_0
+ B1=Write_Address[7] B2=write_enable Y=n_3
Xg733__7482 NAND2xp33_ASAP7_75t_SL $PINS A=read_enable B=n_0 Y=n_1
Xg734__4733 NAND2x2_ASAP7_75t_SRAM $PINS A=write_enable B=Frame Y=mem_WEB
Xg735 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
.ENDS

.SUBCKT CO_MEM_1 write_enable read_enable Sclk Frame Write_Address[8]
+ Write_Address[7] Write_Address[6] Write_Address[5] Write_Address[4]
+ Write_Address[3] Write_Address[2] Write_Address[1] Write_Address[0]
+ Read_Address[8] Read_Address[7] Read_Address[6] Read_Address[5]
+ Read_Address[4] Read_Address[3] Read_Address[2] Read_Address[1]
+ Read_Address[0] data_in[15] data_in[14] data_in[13] data_in[12] data_in[11]
+ data_in[10] data_in[9] data_in[8] data_in[7] data_in[6] data_in[5] data_in[4]
+ data_in[3] data_in[2] data_in[1] data_in[0] Coeff[15] Coeff[14] Coeff[13]
+ Coeff[12] Coeff[11] Coeff[10] Coeff[9] Coeff[8] Coeff[7] Coeff[6] Coeff[5]
+ Coeff[4] Coeff[3] Coeff[2] Coeff[1] Coeff[0]
*.CONNECT Coeff[9] VSS
*.CONNECT Coeff[10] VSS
*.CONNECT Coeff[11] VSS
*.CONNECT Coeff[12] VSS
*.CONNECT Coeff[13] VSS
*.CONNECT Coeff[14] VSS
*.CONNECT Coeff[15] VSS
Xmem_0_0 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_0_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_0_O[11] O[10]=mem_0_O[10] O[9]=mem_0_O[9] O[8]=mem_0_O[8]
+ O[7]=mem_0_O[7] O[6]=mem_0_O[6] O[5]=mem_0_O[5] O[4]=mem_0_O[4] O[3]=mem_0_O[3]
+ O[2]=mem_0_O[2] O[1]=mem_0_O[1] O[0]=mem_0_O[0]
Xmem_0_1 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_1_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_1_O[11] O[10]=mem_1_O[10] O[9]=mem_1_O[9] O[8]=mem_1_O[8]
+ O[7]=mem_1_O[7] O[6]=mem_1_O[6] O[5]=mem_1_O[5] O[4]=mem_1_O[4] O[3]=mem_1_O[3]
+ O[2]=mem_1_O[2] O[1]=mem_1_O[1] O[0]=mem_1_O[0]
Xmem_0_2 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_2_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_2_O[11] O[10]=mem_2_O[10] O[9]=mem_2_O[9] O[8]=mem_2_O[8]
+ O[7]=mem_2_O[7] O[6]=mem_2_O[6] O[5]=mem_2_O[5] O[4]=mem_2_O[4] O[3]=mem_2_O[3]
+ O[2]=mem_2_O[2] O[1]=mem_2_O[1] O[0]=mem_2_O[0]
Xmem_0_3 SRAM1RW128x12 $PINS CE=Sclk WEB=mem_WEB OEB=mem_OEB CSB=mem_3_CSB
+ A[6]=RW0_addr[6] A[5]=RW0_addr[5] A[4]=RW0_addr[4] A[3]=RW0_addr[3]
+ A[2]=RW0_addr[2] A[1]=RW0_addr[1] A[0]=RW0_addr[0] I[11]=VSS I[10]=VSS I[9]=VSS
+ I[8]=data_in[8] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5] I[4]=data_in[4]
+ I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[11]=mem_3_O[11] O[10]=mem_3_O[10] O[9]=mem_3_O[9] O[8]=mem_3_O[8]
+ O[7]=mem_3_O[7] O[6]=mem_3_O[6] O[5]=mem_3_O[5] O[4]=mem_3_O[4] O[3]=mem_3_O[3]
+ O[2]=mem_3_O[2] O[1]=mem_3_O[1] O[0]=mem_3_O[0]
XRW0_rdata_reg[5] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_38 Q=Coeff[5]
XRW0_rdata_reg[7] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_32 Q=Coeff[7]
XRW0_rdata_reg[8] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_33 Q=Coeff[8]
XRW0_rdata_reg[1] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_31 Q=Coeff[1]
XRW0_rdata_reg[6] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_35 Q=Coeff[6]
XRW0_rdata_reg[4] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_37 Q=Coeff[4]
XRW0_rdata_reg[0] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_34 Q=Coeff[0]
XRW0_rdata_reg[3] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_36 Q=Coeff[3]
XRW0_rdata_reg[2] DLLx1_ASAP7_75t_SL $PINS CLK=mem_OEB D=n_30 Q=Coeff[2]
Xg682__6161 NAND2xp33_ASAP7_75t_SL $PINS A=n_23 B=n_24 Y=n_38
Xg683__9315 NAND2xp33_ASAP7_75t_SL $PINS A=n_25 B=n_26 Y=n_37
Xg684__9945 NAND2xp33_ASAP7_75t_SL $PINS A=n_27 B=n_28 Y=n_36
Xg685__2883 NAND2xp33_ASAP7_75t_SL $PINS A=n_29 B=n_22 Y=n_35
Xg686__2346 NAND2xp33_ASAP7_75t_SL $PINS A=n_15 B=n_16 Y=n_34
Xg687__1666 NAND2xp33_ASAP7_75t_SL $PINS A=n_17 B=n_18 Y=n_33
Xg688__7410 NAND2xp33_ASAP7_75t_SL $PINS A=n_19 B=n_12 Y=n_32
Xg689__6417 NAND2xp33_ASAP7_75t_SL $PINS A=n_13 B=n_14 Y=n_31
Xg690__5477 NAND2xp33_ASAP7_75t_SL $PINS A=n_21 B=n_20 Y=n_30
Xg691__2398 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[6] A2=n_8 B1=n_10
+ B2=mem_1_O[6] Y=n_29
Xg692__5107 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[3] A2=n_11 B1=n_9
+ B2=mem_3_O[3] Y=n_28
Xg693__6260 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[3] A2=n_8 B1=n_10
+ B2=mem_1_O[3] Y=n_27
Xg694__4319 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[4] A2=n_11 B1=n_9
+ B2=mem_3_O[4] Y=n_26
Xg695__8428 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[4] A2=n_8 B1=n_10
+ B2=mem_1_O[4] Y=n_25
Xg696__5526 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[5] A2=n_11 B1=n_9
+ B2=mem_3_O[5] Y=n_24
Xg697__6783 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[5] A2=n_8 B1=n_10
+ B2=mem_1_O[5] Y=n_23
Xg698__3680 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[6] A2=n_11 B1=n_9
+ B2=mem_3_O[6] Y=n_22
Xg699__1617 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[2] A2=n_8 B1=n_10
+ B2=mem_1_O[2] Y=n_21
Xg700__2802 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[2] A2=n_11 B1=n_9
+ B2=mem_3_O[2] Y=n_20
Xg701__1705 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[7] A2=n_8 B1=n_10
+ B2=mem_1_O[7] Y=n_19
Xg702__5122 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[8] A2=n_11 B1=n_9
+ B2=mem_3_O[8] Y=n_18
Xg703__8246 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[8] A2=n_8 B1=n_10
+ B2=mem_1_O[8] Y=n_17
Xg704__7098 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[0] A2=n_11 B1=n_9
+ B2=mem_3_O[0] Y=n_16
Xg705__6131 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[0] A2=n_8 B1=n_10
+ B2=mem_1_O[0] Y=n_15
Xg706__1881 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[1] A2=n_11 B1=n_9
+ B2=mem_3_O[1] Y=n_14
Xg707__5115 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_0_O[1] A2=n_8 B1=n_10
+ B2=mem_1_O[1] Y=n_13
Xg708__7482 AOI22xp33_ASAP7_75t_SL $PINS A1=mem_2_O[7] A2=n_11 B1=n_9
+ B2=mem_3_O[7] Y=n_12
Xg709__4733 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[0] B=n_6 Y=n_11
Xg710__6161 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[1] B=n_7 Y=n_10
Xg711__9315 NOR2xp33_ASAP7_75t_SL $PINS A=n_7 B=n_6 Y=n_9
Xg712__9945 NOR2xp33_ASAP7_75t_SL $PINS A=cs_vec[0] B=cs_vec[1] Y=n_8
Xg713 INVx1_ASAP7_75t_SL $PINS A=cs_vec[0] Y=n_7
Xg714 INVx1_ASAP7_75t_SL $PINS A=cs_vec[1] Y=n_6
Xg715__2883 OR2x2_ASAP7_75t_SRAM $PINS A=n_3 B=n_5 Y=mem_3_CSB
Xcs_vec_reg[0] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_3 QN=cs_vec[0]
Xcs_vec_reg[1] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_5 QN=cs_vec[1]
Xg718__2346 NAND2xp33_ASAP7_75t_SL $PINS A=n_5 B=n_3 Y=mem_0_CSB
Xg719__1666 NAND2xp33_ASAP7_75t_SL $PINS A=n_2 B=n_5 Y=mem_1_CSB
Xg720__7410 NAND2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_3 Y=mem_2_CSB
Xg721 INVxp67_ASAP7_75t_SL $PINS A=n_5 Y=n_4
Xg722__6417 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg723__5477 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[4] A2=n_0
+ B1=Write_Address[4] B2=write_enable Y=RW0_addr[4]
Xg724__2398 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[5] A2=n_0
+ B1=Write_Address[5] B2=write_enable Y=RW0_addr[5]
Xg725__5107 AOI22xp5_ASAP7_75t_SL $PINS A1=Read_Address[8] A2=n_0
+ B1=Write_Address[8] B2=write_enable Y=n_5
Xg726__6260 OA21x2_ASAP7_75t_L $PINS A1=Frame A2=n_0 B=n_1 Y=mem_OEB
Xg727 INVxp67_ASAP7_75t_SL $PINS A=n_3 Y=n_2
Xg728__4319 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg729__8428 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[6] A2=n_0
+ B1=Write_Address[6] B2=write_enable Y=RW0_addr[6]
Xg730__5526 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg731__6783 AO22x2_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg732__3680 AOI22xp5_ASAP7_75t_SL $PINS A1=Read_Address[7] A2=n_0
+ B1=Write_Address[7] B2=write_enable Y=n_3
Xg733__1617 NAND2xp33_ASAP7_75t_SL $PINS A=read_enable B=n_0 Y=n_1
Xg734__2802 NAND2x2_ASAP7_75t_SRAM $PINS A=write_enable B=Frame Y=mem_WEB
Xg735 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
.ENDS

.SUBCKT DATA_MEM write_enable read_enable Sclk Frame input_ready
+ Write_Address[7] Write_Address[6] Write_Address[5] Write_Address[4]
+ Write_Address[3] Write_Address[2] Write_Address[1] Write_Address[0]
+ Read_Address[7] Read_Address[6] Read_Address[5] Read_Address[4]
+ Read_Address[3] Read_Address[2] Read_Address[1] Read_Address[0] data_in[15]
+ data_in[14] data_in[13] data_in[12] data_in[11] data_in[10] data_in[9]
+ data_in[8] data_in[7] data_in[6] data_in[5] data_in[4] data_in[3] data_in[2]
+ data_in[1] data_in[0] data_stored[15] data_stored[14] data_stored[13]
+ data_stored[12] data_stored[11] data_stored[10] data_stored[9] data_stored[8]
+ data_stored[7] data_stored[6] data_stored[5] data_stored[4] data_stored[3]
+ data_stored[2] data_stored[1] data_stored[0] allzeros
Xmem_0_0 SRAM1RW256x8 $PINS CE=Sclk WEB=mem_0_0_WEB OEB=mem_0_0_OEB
+ CSB=mem_0_0_CSB A[7]=RW0_addr[7] A[6]=RW0_addr[6] A[5]=RW0_addr[5]
+ A[4]=RW0_addr[4] A[3]=RW0_addr[3] A[2]=RW0_addr[2] A[1]=RW0_addr[1]
+ A[0]=RW0_addr[0] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5]
+ I[4]=data_in[4] I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[7]=mem_0_0_O[7] O[6]=mem_0_0_O[6] O[5]=mem_0_0_O[5] O[4]=mem_0_0_O[4]
+ O[3]=mem_0_0_O[3] O[2]=mem_0_0_O[2] O[1]=mem_0_0_O[1] O[0]=mem_0_0_O[0]
Xmem_0_1 SRAM1RW256x8 $PINS CE=Sclk WEB=mem_0_0_WEB OEB=mem_0_0_OEB
+ CSB=mem_0_0_CSB A[7]=RW0_addr[7] A[6]=RW0_addr[6] A[5]=RW0_addr[5]
+ A[4]=RW0_addr[4] A[3]=RW0_addr[3] A[2]=RW0_addr[2] A[1]=RW0_addr[1]
+ A[0]=RW0_addr[0] I[7]=data_in[15] I[6]=data_in[14] I[5]=data_in[13]
+ I[4]=data_in[12] I[3]=data_in[11] I[2]=data_in[10] I[1]=data_in[9]
+ I[0]=data_in[8] O[7]=mem_0_1_O[7] O[6]=mem_0_1_O[6] O[5]=mem_0_1_O[5]
+ O[4]=mem_0_1_O[4] O[3]=mem_0_1_O[3] O[2]=mem_0_1_O[2] O[1]=mem_0_1_O[1]
+ O[0]=mem_0_1_O[0]
Xcount_zero_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_40
+ QN=count_zero[1]
Xcount_zero_reg[8] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_39
+ QN=count_zero[8]
Xcount_zero_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_44
+ QN=count_zero[2]
Xcount_zero_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_46
+ QN=count_zero[0]
Xcount_zero_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_41
+ QN=count_zero[4]
Xcount_zero_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_45
+ QN=count_zero[3]
Xcount_zero_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_42
+ QN=count_zero[6]
Xcount_zero_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_43
+ QN=count_zero[7]
Xg1584__1705 OR2x2_ASAP7_75t_SRAM $PINS A=n_36 B=count_zero[0] Y=n_46
Xg1585__5122 NAND2xp33_ASAP7_75t_SL $PINS A=n_16 B=n_37 Y=n_45
Xg1586__8246 NAND2xp33_ASAP7_75t_SL $PINS A=n_14 B=n_37 Y=n_44
Xcount_zero_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_38
+ QN=count_zero[5]
Xallzeros_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_35 QN=allzeros
Xg1589__7098 NAND2xp33_ASAP7_75t_SL $PINS A=n_30 B=n_37 Y=n_43
Xg1590__6131 NAND2xp33_ASAP7_75t_SL $PINS A=n_27 B=n_37 Y=n_42
Xg1591__1881 NAND2xp33_ASAP7_75t_SL $PINS A=n_20 B=n_37 Y=n_41
Xg1592__5115 NAND2xp33_ASAP7_75t_SL $PINS A=n_7 B=n_37 Y=n_40
Xg1593__7482 AOI221xp5_ASAP7_75t_R $PINS A1=n_18 A2=n_31 B1=n_28 B2=n_21 C=n_34
+ Y=n_39
Xg1594__4733 AOI31xp33_ASAP7_75t_SL $PINS A1=n_18 A2=n_22 A3=n_24 B=n_34 Y=n_38
Xcount_zero_reg[9] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_33
+ QN=count_zero[9]
Xg1596 INVx1_ASAP7_75t_SL $PINS A=n_37 Y=n_36
Xg1597__6161 AOI21xp33_ASAP7_75t_SL $PINS A1=allzeros A2=n_18 B=n_34 Y=n_35
Xg1598__9315 AOI21xp33_ASAP7_75t_SL $PINS A1=count_zero[8] A2=n_32 B=n_17
+ Y=n_37
Xg1599__9945 AND2x2_ASAP7_75t_R $PINS A=n_32 B=n_21 Y=n_34
Xg1600__2883 AOI22xp33_ASAP7_75t_SL $PINS A1=n_29 A2=n_21 B1=count_zero[9]
+ B2=n_18 Y=n_33
Xg1601__2346 OA31x2_ASAP7_75t_SL $PINS A1=count_zero[6] A2=count_zero[7]
+ A3=n_24 B1=count_zero[9] Y=n_32
Xg1602__1666 NOR2xp33_ASAP7_75t_SL $PINS A=count_zero[8] B=n_28 Y=n_31
Xg1603__7410 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[7] B=n_25 Y=n_30
Xg1604 INVx1_ASAP7_75t_SL $PINS A=n_28 Y=n_29
Xg1605__6417 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[7] B=n_26 Y=n_28
Xg1606__5477 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[6] B=n_22 Y=n_27
Xg1607 INVx1_ASAP7_75t_SL $PINS A=n_25 Y=n_26
Xg1608__2398 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[6] B=n_23 Y=n_25
Xg1609 INVx1_ASAP7_75t_SL $PINS A=n_22 Y=n_23
Xg1610__5107 OR2x2_ASAP7_75t_SRAM $PINS A=n_19 B=count_zero[5] Y=n_24
Xg1611__6260 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[5] B=n_19 Y=n_22
Xg1612__4319 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[4] B=n_15 Y=n_20
Xg1613__8428 AND2x2_ASAP7_75t_R $PINS A=n_18 B=count_zero[8] Y=n_21
Xg1614__5526 NOR2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_15 Y=n_19
Xg1615 INVx1_ASAP7_75t_SL $PINS A=n_17 Y=n_18
Xg1616__6783 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[3] B=n_12 Y=n_16
Xg1617__3680 NAND4xp25_ASAP7_75t_R $PINS A=n_10 B=n_9 C=n_11 D=n_8 Y=n_17
Xg1618__1617 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[3] B=n_13 Y=n_15
Xg1619__2802 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[2] B=n_5 Y=n_14
Xg1620 INVx1_ASAP7_75t_SL $PINS A=n_12 Y=n_13
Xg1621__1705 NOR4xp25_ASAP7_75t_R $PINS A=data_in[0] B=data_in[2] C=data_in[1]
+ D=data_in[3] Y=n_11
Xg1622__5122 NOR4xp25_ASAP7_75t_R $PINS A=data_in[12] B=data_in[15]
+ C=data_in[14] D=data_in[13] Y=n_10
Xg1623__8246 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[2] B=n_6 Y=n_12
Xg1624__7098 NOR4xp25_ASAP7_75t_R $PINS A=data_in[4] B=data_in[7] C=data_in[6]
+ D=data_in[5] Y=n_9
Xg1625__6131 NOR4xp25_ASAP7_75t_R $PINS A=data_in[9] B=data_in[11] C=n_3
+ D=data_in[10] Y=n_8
Xg1626__1881 XOR2xp5_ASAP7_75t_R $PINS A=count_zero[1] B=count_zero[0] Y=n_7
Xg1627 INVx1_ASAP7_75t_SL $PINS A=n_5 Y=n_6
Xg1628__5115 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[1] B=count_zero[0] Y=n_5
Xg1629 INVx1_ASAP7_75t_SL $PINS A=count_zero[4] Y=n_4
Xdrc_bufs HB1xp67_ASAP7_75t_SL $PINS A=data_in[8] Y=n_3
Xg1498__7482 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[6] A2=n_0
+ B1=Write_Address[6] B2=write_enable Y=RW0_addr[6]
Xg1499__4733 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[7] A2=n_0
+ B1=Write_Address[7] B2=write_enable Y=RW0_addr[7]
Xg1500__6161 OR2x2_ASAP7_75t_SRAM $PINS A=n_2 B=mem_0_0_CSB Y=mem_0_0_OEB
Xg1501__9315 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg1502__9945 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[4] A2=n_0
+ B1=Write_Address[4] B2=write_enable Y=RW0_addr[4]
Xg1503__2883 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[5] A2=n_0
+ B1=Write_Address[5] B2=write_enable Y=RW0_addr[5]
Xg1504__2346 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg1505__1666 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg1506__7410 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg1507 INVx1_ASAP7_75t_L $PINS A=mem_0_0_WEB Y=n_2
Xg1508__6417 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[6]
+ Y=data_stored[6]
Xg1509__5477 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[0]
+ Y=data_stored[0]
Xg1510__2398 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[0]
+ Y=data_stored[8]
Xg1511__5107 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[6]
+ Y=data_stored[14]
Xg1512__6260 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[7]
+ Y=data_stored[7]
Xg1513__4319 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[4]
+ Y=data_stored[12]
Xg1514__8428 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[7]
+ Y=data_stored[15]
Xg1515__5526 AND2x2_ASAP7_75t_SL $PINS A=n_1 B=n_0 Y=mem_0_0_CSB
Xg1516__6783 NAND2x2_ASAP7_75t_SL $PINS A=Frame B=write_enable Y=mem_0_0_WEB
Xg1517__3680 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[1]
+ Y=data_stored[1]
Xg1518__1617 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[5]
+ Y=data_stored[5]
Xg1519__2802 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[2]
+ Y=data_stored[10]
Xg1520__1705 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[4]
+ Y=data_stored[4]
Xg1521__5122 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[3]
+ Y=data_stored[3]
Xg1522__8246 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[5]
+ Y=data_stored[13]
Xg1523__7098 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[1]
+ Y=data_stored[9]
Xg1524__6131 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[2]
+ Y=data_stored[2]
Xg1525__1881 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[3]
+ Y=data_stored[11]
Xg1526 INVxp67_ASAP7_75t_SL $PINS A=read_enable Y=n_1
Xg1527 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
.ENDS

.SUBCKT DATA_MEM_1 write_enable read_enable Sclk Frame input_ready
+ Write_Address[7] Write_Address[6] Write_Address[5] Write_Address[4]
+ Write_Address[3] Write_Address[2] Write_Address[1] Write_Address[0]
+ Read_Address[7] Read_Address[6] Read_Address[5] Read_Address[4]
+ Read_Address[3] Read_Address[2] Read_Address[1] Read_Address[0] data_in[15]
+ data_in[14] data_in[13] data_in[12] data_in[11] data_in[10] data_in[9]
+ data_in[8] data_in[7] data_in[6] data_in[5] data_in[4] data_in[3] data_in[2]
+ data_in[1] data_in[0] data_stored[15] data_stored[14] data_stored[13]
+ data_stored[12] data_stored[11] data_stored[10] data_stored[9] data_stored[8]
+ data_stored[7] data_stored[6] data_stored[5] data_stored[4] data_stored[3]
+ data_stored[2] data_stored[1] data_stored[0] allzeros
Xmem_0_0 SRAM1RW256x8 $PINS CE=Sclk WEB=mem_0_0_WEB OEB=mem_0_0_OEB
+ CSB=mem_0_0_CSB A[7]=RW0_addr[7] A[6]=RW0_addr[6] A[5]=RW0_addr[5]
+ A[4]=RW0_addr[4] A[3]=RW0_addr[3] A[2]=RW0_addr[2] A[1]=RW0_addr[1]
+ A[0]=RW0_addr[0] I[7]=data_in[7] I[6]=data_in[6] I[5]=data_in[5]
+ I[4]=data_in[4] I[3]=data_in[3] I[2]=data_in[2] I[1]=data_in[1] I[0]=data_in[0]
+ O[7]=mem_0_0_O[7] O[6]=mem_0_0_O[6] O[5]=mem_0_0_O[5] O[4]=mem_0_0_O[4]
+ O[3]=mem_0_0_O[3] O[2]=mem_0_0_O[2] O[1]=mem_0_0_O[1] O[0]=mem_0_0_O[0]
Xmem_0_1 SRAM1RW256x8 $PINS CE=Sclk WEB=mem_0_0_WEB OEB=mem_0_0_OEB
+ CSB=mem_0_0_CSB A[7]=RW0_addr[7] A[6]=RW0_addr[6] A[5]=RW0_addr[5]
+ A[4]=RW0_addr[4] A[3]=RW0_addr[3] A[2]=RW0_addr[2] A[1]=RW0_addr[1]
+ A[0]=RW0_addr[0] I[7]=data_in[15] I[6]=data_in[14] I[5]=data_in[13]
+ I[4]=data_in[12] I[3]=data_in[11] I[2]=data_in[10] I[1]=data_in[9]
+ I[0]=data_in[8] O[7]=mem_0_1_O[7] O[6]=mem_0_1_O[6] O[5]=mem_0_1_O[5]
+ O[4]=mem_0_1_O[4] O[3]=mem_0_1_O[3] O[2]=mem_0_1_O[2] O[1]=mem_0_1_O[1]
+ O[0]=mem_0_1_O[0]
Xcount_zero_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_40
+ QN=count_zero[1]
Xcount_zero_reg[8] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_39
+ QN=count_zero[8]
Xcount_zero_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_44
+ QN=count_zero[2]
Xcount_zero_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_46
+ QN=count_zero[0]
Xcount_zero_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_41
+ QN=count_zero[4]
Xcount_zero_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_45
+ QN=count_zero[3]
Xcount_zero_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_42
+ QN=count_zero[6]
Xcount_zero_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_43
+ QN=count_zero[7]
Xg1584__5115 OR2x2_ASAP7_75t_SRAM $PINS A=n_36 B=count_zero[0] Y=n_46
Xg1585__7482 NAND2xp33_ASAP7_75t_SL $PINS A=n_16 B=n_37 Y=n_45
Xg1586__4733 NAND2xp33_ASAP7_75t_SL $PINS A=n_14 B=n_37 Y=n_44
Xcount_zero_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_38
+ QN=count_zero[5]
Xallzeros_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_35 QN=allzeros
Xg1589__6161 NAND2xp33_ASAP7_75t_SL $PINS A=n_30 B=n_37 Y=n_43
Xg1590__9315 NAND2xp33_ASAP7_75t_SL $PINS A=n_27 B=n_37 Y=n_42
Xg1591__9945 NAND2xp33_ASAP7_75t_SL $PINS A=n_20 B=n_37 Y=n_41
Xg1592__2883 NAND2xp33_ASAP7_75t_SL $PINS A=n_7 B=n_37 Y=n_40
Xg1593__2346 AOI221xp5_ASAP7_75t_R $PINS A1=n_18 A2=n_31 B1=n_28 B2=n_21 C=n_34
+ Y=n_39
Xg1594__1666 AOI31xp33_ASAP7_75t_SL $PINS A1=n_18 A2=n_22 A3=n_24 B=n_34 Y=n_38
Xcount_zero_reg[9] DFFHQNx1_ASAP7_75t_SL $PINS CLK=input_ready D=n_33
+ QN=count_zero[9]
Xg1596 INVx1_ASAP7_75t_SL $PINS A=n_37 Y=n_36
Xg1597__7410 AOI21xp33_ASAP7_75t_SL $PINS A1=allzeros A2=n_18 B=n_34 Y=n_35
Xg1598__6417 AOI21xp33_ASAP7_75t_SL $PINS A1=count_zero[8] A2=n_32 B=n_17
+ Y=n_37
Xg1599__5477 AND2x2_ASAP7_75t_R $PINS A=n_32 B=n_21 Y=n_34
Xg1600__2398 AOI22xp33_ASAP7_75t_SL $PINS A1=n_29 A2=n_21 B1=count_zero[9]
+ B2=n_18 Y=n_33
Xg1601__5107 OA31x2_ASAP7_75t_SL $PINS A1=count_zero[6] A2=count_zero[7]
+ A3=n_24 B1=count_zero[9] Y=n_32
Xg1602__6260 NOR2xp33_ASAP7_75t_SL $PINS A=count_zero[8] B=n_28 Y=n_31
Xg1603__4319 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[7] B=n_25 Y=n_30
Xg1604 INVx1_ASAP7_75t_SL $PINS A=n_28 Y=n_29
Xg1605__8428 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[7] B=n_26 Y=n_28
Xg1606__5526 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[6] B=n_22 Y=n_27
Xg1607 INVx1_ASAP7_75t_SL $PINS A=n_25 Y=n_26
Xg1608__6783 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[6] B=n_23 Y=n_25
Xg1609 INVx1_ASAP7_75t_SL $PINS A=n_22 Y=n_23
Xg1610__3680 OR2x2_ASAP7_75t_SRAM $PINS A=n_19 B=count_zero[5] Y=n_24
Xg1611__1617 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[5] B=n_19 Y=n_22
Xg1612__2802 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[4] B=n_15 Y=n_20
Xg1613__1705 AND2x2_ASAP7_75t_R $PINS A=n_18 B=count_zero[8] Y=n_21
Xg1614__5122 NOR2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_15 Y=n_19
Xg1615 INVx1_ASAP7_75t_SL $PINS A=n_17 Y=n_18
Xg1616__8246 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[3] B=n_12 Y=n_16
Xg1617__7098 NAND4xp25_ASAP7_75t_R $PINS A=n_10 B=n_9 C=n_11 D=n_8 Y=n_17
Xg1618__6131 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[3] B=n_13 Y=n_15
Xg1619__1881 XNOR2xp5_ASAP7_75t_SRAM $PINS A=count_zero[2] B=n_5 Y=n_14
Xg1620 INVx1_ASAP7_75t_SL $PINS A=n_12 Y=n_13
Xg1621__5115 NOR4xp25_ASAP7_75t_R $PINS A=data_in[0] B=data_in[2] C=data_in[1]
+ D=data_in[3] Y=n_11
Xg1622__7482 NOR4xp25_ASAP7_75t_R $PINS A=data_in[12] B=data_in[15]
+ C=data_in[14] D=data_in[13] Y=n_10
Xg1623__4733 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[2] B=n_6 Y=n_12
Xg1624__6161 NOR4xp25_ASAP7_75t_R $PINS A=data_in[4] B=data_in[7] C=data_in[6]
+ D=data_in[5] Y=n_9
Xg1625__9315 NOR4xp25_ASAP7_75t_R $PINS A=data_in[9] B=data_in[11] C=n_3
+ D=data_in[10] Y=n_8
Xg1626__9945 XOR2xp5_ASAP7_75t_R $PINS A=count_zero[1] B=count_zero[0] Y=n_7
Xg1627 INVx1_ASAP7_75t_SL $PINS A=n_5 Y=n_6
Xg1628__2883 NAND2xp33_ASAP7_75t_SL $PINS A=count_zero[1] B=count_zero[0] Y=n_5
Xg1629 INVx1_ASAP7_75t_SL $PINS A=count_zero[4] Y=n_4
Xdrc_bufs HB1xp67_ASAP7_75t_SL $PINS A=data_in[8] Y=n_3
Xg1498__2346 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[6] A2=n_0
+ B1=Write_Address[6] B2=write_enable Y=RW0_addr[6]
Xg1499__1666 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[7] A2=n_0
+ B1=Write_Address[7] B2=write_enable Y=RW0_addr[7]
Xg1500__7410 OR2x2_ASAP7_75t_SRAM $PINS A=n_2 B=mem_0_0_CSB Y=mem_0_0_OEB
Xg1501__6417 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg1502__5477 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[4] A2=n_0
+ B1=Write_Address[4] B2=write_enable Y=RW0_addr[4]
Xg1503__2398 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[5] A2=n_0
+ B1=Write_Address[5] B2=write_enable Y=RW0_addr[5]
Xg1504__5107 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg1505__6260 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg1506__4319 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg1507 INVx1_ASAP7_75t_L $PINS A=mem_0_0_WEB Y=n_2
Xg1508__8428 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[6]
+ Y=data_stored[6]
Xg1509__5526 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[0]
+ Y=data_stored[0]
Xg1510__6783 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[0]
+ Y=data_stored[8]
Xg1511__3680 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[6]
+ Y=data_stored[14]
Xg1512__1617 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[7]
+ Y=data_stored[7]
Xg1513__2802 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[4]
+ Y=data_stored[12]
Xg1514__1705 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[7]
+ Y=data_stored[15]
Xg1515__5122 AND2x2_ASAP7_75t_SL $PINS A=n_1 B=n_0 Y=mem_0_0_CSB
Xg1516__8246 NAND2x2_ASAP7_75t_SL $PINS A=Frame B=write_enable Y=mem_0_0_WEB
Xg1517__7098 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[1]
+ Y=data_stored[1]
Xg1518__6131 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[5]
+ Y=data_stored[5]
Xg1519__1881 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[2]
+ Y=data_stored[10]
Xg1520__5115 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[4]
+ Y=data_stored[4]
Xg1521__7482 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[3]
+ Y=data_stored[3]
Xg1522__4733 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[5]
+ Y=data_stored[13]
Xg1523__6161 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[1]
+ Y=data_stored[9]
Xg1524__9315 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_0_O[2]
+ Y=data_stored[2]
Xg1525__9945 AND2x2_ASAP7_75t_SL $PINS A=read_enable B=mem_0_1_O[3]
+ Y=data_stored[11]
Xg1526 INVxp67_ASAP7_75t_SL $PINS A=read_enable Y=n_1
Xg1527 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
.ENDS

.SUBCKT PISO Sclk Clear Frame enable_PISO InputParallel[39] InputParallel[38]
+ InputParallel[37] InputParallel[36] InputParallel[35] InputParallel[34]
+ InputParallel[33] InputParallel[32] InputParallel[31] InputParallel[30]
+ InputParallel[29] InputParallel[28] InputParallel[27] InputParallel[26]
+ InputParallel[25] InputParallel[24] InputParallel[23] InputParallel[22]
+ InputParallel[21] InputParallel[20] InputParallel[19] InputParallel[18]
+ InputParallel[17] InputParallel[16] InputParallel[15] InputParallel[14]
+ InputParallel[13] InputParallel[12] InputParallel[11] InputParallel[10]
+ InputParallel[9] InputParallel[8] InputParallel[7] InputParallel[6]
+ InputParallel[5] InputParallel[4] InputParallel[3] InputParallel[2]
+ InputParallel[1] InputParallel[0] OutputSerial OutReady
XOutReady_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_167 QN=OutReady
XOutputSerial_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_191 QN=OutputSerial
Xcount_bit_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_181 QN=count_bit[0]
Xcount_bit_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_184 QN=count_bit[1]
Xcount_bit_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_188 QN=count_bit[2]
Xcount_bit_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_177 QN=count_bit[3]
Xcount_bit_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_185 QN=count_bit[4]
Xcount_bit_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_175 QN=count_bit[5]
Xready_out_reg SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=Clear SE=n_28 SI=n_128
+ QN=ready_out
Xregister_dataout_reg[0] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_127
+ QN=register_dataout[0]
Xregister_dataout_reg[1] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_126
+ QN=register_dataout[1]
Xregister_dataout_reg[2] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_125
+ QN=register_dataout[2]
Xregister_dataout_reg[3] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_124
+ QN=register_dataout[3]
Xregister_dataout_reg[4] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_123
+ QN=register_dataout[4]
Xregister_dataout_reg[5] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_122
+ QN=register_dataout[5]
Xregister_dataout_reg[6] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_121
+ QN=register_dataout[6]
Xregister_dataout_reg[7] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_120
+ QN=register_dataout[7]
Xregister_dataout_reg[8] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_132
+ QN=register_dataout[8]
Xregister_dataout_reg[9] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_118
+ QN=register_dataout[9]
Xregister_dataout_reg[10] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_117
+ QN=register_dataout[10]
Xregister_dataout_reg[11] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_116
+ QN=register_dataout[11]
Xregister_dataout_reg[12] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_115
+ QN=register_dataout[12]
Xregister_dataout_reg[13] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_114
+ QN=register_dataout[13]
Xregister_dataout_reg[14] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_113
+ QN=register_dataout[14]
Xregister_dataout_reg[15] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_111
+ QN=register_dataout[15]
Xregister_dataout_reg[16] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_110
+ QN=register_dataout[16]
Xregister_dataout_reg[17] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_112
+ QN=register_dataout[17]
Xregister_dataout_reg[18] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_109
+ QN=register_dataout[18]
Xregister_dataout_reg[19] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_108
+ QN=register_dataout[19]
Xregister_dataout_reg[20] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_119
+ QN=register_dataout[20]
Xregister_dataout_reg[21] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_85
+ QN=register_dataout[21]
Xregister_dataout_reg[22] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_97
+ QN=register_dataout[22]
Xregister_dataout_reg[23] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_96
+ QN=register_dataout[23]
Xregister_dataout_reg[24] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_95
+ QN=register_dataout[24]
Xregister_dataout_reg[25] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_94
+ QN=register_dataout[25]
Xregister_dataout_reg[26] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_93
+ QN=register_dataout[26]
Xregister_dataout_reg[27] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_92
+ QN=register_dataout[27]
Xregister_dataout_reg[28] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_91
+ QN=register_dataout[28]
Xregister_dataout_reg[29] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_90
+ QN=register_dataout[29]
Xregister_dataout_reg[30] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_131
+ QN=register_dataout[30]
Xregister_dataout_reg[31] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_88
+ QN=register_dataout[31]
Xregister_dataout_reg[32] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_129
+ QN=register_dataout[32]
Xregister_dataout_reg[33] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_87
+ QN=register_dataout[33]
Xregister_dataout_reg[34] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_86
+ QN=register_dataout[34]
Xregister_dataout_reg[35] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_98
+ QN=register_dataout[35]
Xregister_dataout_reg[36] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_130
+ QN=register_dataout[36]
Xregister_dataout_reg[37] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_84
+ QN=register_dataout[37]
Xregister_dataout_reg[38] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_83
+ QN=register_dataout[38]
Xregister_dataout_reg[39] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_82
+ QN=register_dataout[39]
Xg3441__2883 AOI33xp33_ASAP7_75t_SL $PINS A1=n_28 A2=n_163 A3=n_190 B1=n_162
+ B2=n_1 B3=OutputSerial Y=n_191
Xg3442__2346 AOI31xp33_ASAP7_75t_SL $PINS A1=n_187 A2=n_171 A3=count_bit[4]
+ B=n_189 Y=n_190
Xg3443__1666 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=count_bit[1] A2=n_186 B=n_183
+ C=count_bit[4] Y=n_189
Xg3446__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=count_bit[2] A2=n_182 B1=n_75
+ B2=n_172 Y=n_188
Xg3448__6417 OAI21xp5_ASAP7_75t_SL $PINS A1=n_106 A2=n_173 B=count_bit[1]
+ Y=n_187
Xg3450__5477 OR4x1_ASAP7_75t_SL $PINS A=n_170 B=n_153 C=n_147 D=n_106 Y=n_186
Xg3451__2398 AOI22xp5_ASAP7_75t_SL $PINS A1=count_bit[4] A2=n_176 B1=n_140
+ B2=n_172 Y=n_185
Xg3452__5107 AOI21xp5_ASAP7_75t_SL $PINS A1=n_179 A2=count_bit[1] B=n_180
+ Y=n_184
Xg3453__6260 OR5x1_ASAP7_75t_SL $PINS A=n_160 B=n_146 C=n_142 D=n_78 E=n_7
+ Y=n_183
Xg3456__4319 OAI21xp5_ASAP7_75t_SL $PINS A1=n_7 A2=n_166 B=n_178 Y=n_182
Xg3457__8428 AOI22xp5_ASAP7_75t_SL $PINS A1=n_1 A2=n_168 B1=n_29
+ B2=count_bit[0] Y=n_181
Xg3458__5526 AND3x1_ASAP7_75t_SL $PINS A=n_172 B=n_4 C=n_7 Y=n_180
Xg3459 INVxp67_ASAP7_75t_SL $PINS A=n_178 Y=n_179
Xg3460__6783 OA211x2_ASAP7_75t_SL $PINS A1=n_101 A2=n_162 B=n_169 C=n_137
+ Y=n_177
Xg3461__3680 AOI21xp5_ASAP7_75t_SL $PINS A1=n_165 A2=count_bit[0] B=n_29
+ Y=n_178
Xg3463 INVx1_ASAP7_75t_SL $PINS A=n_174 Y=n_176
Xg3464__1617 OA211x2_ASAP7_75t_SL $PINS A1=n_148 A2=n_162 B=n_169 C=n_152
+ Y=n_175
Xg3465__2802 AOI21xp5_ASAP7_75t_SL $PINS A1=n_165 A2=n_101 B=n_29 Y=n_174
Xg3466__1705 OAI211xp5_ASAP7_75t_SL $PINS A1=count_bit[3] A2=n_157 B=n_149
+ C=n_141 Y=n_173
Xg3467__5122 AOI31xp33_ASAP7_75t_SL $PINS A1=n_158 A2=count_bit[3] A3=n_7
+ B=n_164 Y=n_171
Xg3468__8246 AOI31xp33_ASAP7_75t_SL $PINS A1=n_144 A2=n_150 A3=n_107
+ B=count_bit[3] Y=n_170
Xg3469__7098 NOR2xp33_ASAP7_75t_SL $PINS A=enable_PISO B=n_166 Y=n_172
Xg3470__6131 NOR3xp33_ASAP7_75t_SL $PINS A=n_162 B=n_133 C=count_bit[0] Y=n_168
Xg3471__1881 AOI22xp33_ASAP7_75t_SL $PINS A1=n_159 A2=OutReady B1=n_70 B2=n_28
+ Y=n_167
Xg3472__5115 AOI21xp5_ASAP7_75t_SL $PINS A1=n_161 A2=n_133 B=Clear Y=n_169
Xg3473 INVxp67_ASAP7_75t_SL $PINS A=n_166 Y=n_165
Xg3474__7482 NAND2xp5_ASAP7_75t_SL $PINS A=n_1 B=n_163 Y=n_166
Xg3475__4733 AOI311xp33_ASAP7_75t_SL $PINS A1=n_144 A2=n_89 A3=n_80
+ B=count_bit[1] C=count_bit[3] Y=n_164
Xg3476 INVx1_ASAP7_75t_SL $PINS A=n_162 Y=n_161
Xg3477__6161 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_4 A2=n_135 B=n_134
+ C=count_bit[3] Y=n_160
Xg3478__9315 NOR2xp33_ASAP7_75t_SL $PINS A=n_133 B=n_154 Y=n_163
Xg3479__9945 NAND2xp5_ASAP7_75t_SL $PINS A=n_0 B=n_155 Y=n_162
Xg3480 INVx1_ASAP7_75t_SL $PINS A=n_156 Y=n_159
Xg3481__2883 NAND4xp25_ASAP7_75t_SL $PINS A=n_144 B=n_138 C=n_71 D=n_62 Y=n_158
Xg3482__2346 AOI221xp5_ASAP7_75t_SL $PINS A1=n_136 A2=count_bit[0] B1=n_34
+ B2=register_dataout[22] C=n_151 Y=n_157
Xg3483__1666 AOI21xp5_ASAP7_75t_SL $PINS A1=n_148 A2=n_1 B=n_29 Y=n_156
Xg3484 INVxp67_ASAP7_75t_SL $PINS A=n_154 Y=n_155
Xg3485__7410 AOI31xp33_ASAP7_75t_SL $PINS A1=n_107 A2=n_105 A3=n_72 B=n_5
+ Y=n_153
Xg3486__6417 NOR2xp33_ASAP7_75t_SL $PINS A=n_8 B=n_148 Y=n_154
Xg3488__5477 OAI21xp33_ASAP7_75t_SL $PINS A1=enable_PISO A2=n_139
+ B=count_bit[5] Y=n_152
Xg3489__2398 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_38 A2=n_102 B=count_bit[0]
+ C=n_73 Y=n_151
Xg3490__5107 AOI321xp33_ASAP7_75t_SL $PINS A1=n_30 A2=count_bit[0]
+ A3=register_dataout[4] B1=n_26 B2=register_dataout[31] C=n_143 Y=n_150
Xg3491__6260 AOI31xp33_ASAP7_75t_SL $PINS A1=n_26 A2=count_bit[3]
+ A3=register_dataout[25] B=n_145 Y=n_149
Xg3492__4319 AOI21xp5_ASAP7_75t_SL $PINS A1=n_104 A2=n_68 B=n_61 Y=n_147
Xg3493__8428 AOI31xp33_ASAP7_75t_SL $PINS A1=n_100 A2=n_65 A3=n_62 B=n_61
+ Y=n_146
Xg3494__5526 AOI21xp5_ASAP7_75t_SL $PINS A1=n_100 A2=n_64 B=n_61 Y=n_145
Xg3495__6783 NAND2xp5_ASAP7_75t_SL $PINS A=n_6 B=n_140 Y=n_148
Xg3496__3680 OAI22xp5_ASAP7_75t_SL $PINS A1=count_bit[5] A2=n_81 B1=n_66
+ B2=n_76 Y=n_143
Xg3497__1617 OAI22xp5_ASAP7_75t_SL $PINS A1=count_bit[0] A2=n_102 B1=n_33
+ B2=n_63 Y=n_142
Xg3498__2802 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=register_dataout[29]
+ A2=count_bit[2] B=n_103 C=n_32 Y=n_141
Xg3499__1705 OA21x2_ASAP7_75t_SL $PINS A1=n_4 A2=n_104 B=n_105 Y=n_144
Xg3523 INVxp67_ASAP7_75t_SL $PINS A=n_140 Y=n_139
Xg3524__5122 AOI222xp33_ASAP7_75t_SL $PINS A1=register_dataout[23] A2=n_26
+ B1=n_35 B2=register_dataout[24] C1=register_dataout[28] C2=n_34 Y=n_138
Xg3525__8246 OAI21xp33_ASAP7_75t_SL $PINS A1=enable_PISO A2=n_74 B=count_bit[3]
+ Y=n_137
Xg3526__7098 OAI21xp5_ASAP7_75t_SL $PINS A1=n_2 A2=count_bit[2] B=n_100 Y=n_136
Xg3527__6131 AOI321xp33_ASAP7_75t_SL $PINS A1=n_3 A2=n_6 A3=register_dataout[2]
+ B1=n_30 B2=register_dataout[6] C=n_99 Y=n_135
Xg3528__1881 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=register_dataout[5] A2=n_30
+ B=n_67 C=n_4 Y=n_134
Xg3546__5115 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[4] B=n_101 Y=n_140
Xg3547__7482 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[8]
+ B=n_14 C=n_1 Y=n_132
Xg3548__4733 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[30]
+ B=n_43 C=n_1 Y=n_131
Xg3549__6161 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[36]
+ B=n_47 C=n_1 Y=n_130
Xg3550__9315 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[32]
+ B=n_55 C=n_1 Y=n_129
Xg3551__9945 NAND2xp5_ASAP7_75t_SL $PINS A=ready_out B=n_69 Y=n_128
Xg3552__2883 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[0]
+ B=n_48 C=n_1 Y=n_127
Xg3553__2346 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[1]
+ B=n_16 C=n_1 Y=n_126
Xg3554__1666 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[2]
+ B=n_22 C=n_1 Y=n_125
Xg3555__7410 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[3]
+ B=n_39 C=n_1 Y=n_124
Xg3556__6417 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[4]
+ B=n_44 C=n_1 Y=n_123
Xg3557__5477 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[5]
+ B=n_42 C=n_1 Y=n_122
Xg3558__2398 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[6]
+ B=n_41 C=n_1 Y=n_121
Xg3559__5107 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[7]
+ B=n_56 C=n_1 Y=n_120
Xg3560__6260 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[20]
+ B=n_37 C=n_1 Y=n_119
Xg3561__4319 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[9]
+ B=n_51 C=n_1 Y=n_118
Xg3562__8428 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[10]
+ B=n_24 C=n_1 Y=n_117
Xg3563__5526 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[11]
+ B=n_11 C=n_1 Y=n_116
Xg3564__6783 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[12]
+ B=n_9 C=n_1 Y=n_115
Xg3565__3680 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[13]
+ B=n_13 C=n_1 Y=n_114
Xg3566__1617 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[14]
+ B=n_17 C=n_1 Y=n_113
Xg3567__2802 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[17]
+ B=n_58 C=n_1 Y=n_112
Xg3568__1705 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[15]
+ B=n_23 C=n_1 Y=n_111
Xg3569__5122 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[16]
+ B=n_50 C=n_1 Y=n_110
Xg3570__8246 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[18]
+ B=n_40 C=n_1 Y=n_109
Xg3571__7098 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[19]
+ B=n_46 C=n_1 Y=n_108
Xg3572__6131 NOR2xp33_ASAP7_75t_SL $PINS A=OutReady B=n_70 Y=n_133
Xg3573 INVxp67_ASAP7_75t_SL $PINS A=n_102 Y=n_103
Xg3574 INVx1_ASAP7_75t_SL $PINS A=n_100 Y=n_99
Xg3575__1881 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[35]
+ B=n_49 C=n_1 Y=n_98
Xg3576__5115 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[22]
+ B=n_10 C=n_1 Y=n_97
Xg3577__7482 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[23]
+ B=n_18 C=n_1 Y=n_96
Xg3578__4733 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[24]
+ B=n_15 C=n_1 Y=n_95
Xg3579__6161 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[25]
+ B=n_45 C=n_1 Y=n_94
Xg3580__9315 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[26]
+ B=n_54 C=n_1 Y=n_93
Xg3581__9945 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[27]
+ B=n_19 C=n_1 Y=n_92
Xg3582__2883 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[28]
+ B=n_53 C=n_1 Y=n_91
Xg3583__2346 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[29]
+ B=n_52 C=n_1 Y=n_90
Xg3584__1666 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[16] A2=n_35
+ B1=register_dataout[20] B2=n_34 Y=n_89
Xg3585__7410 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[31]
+ B=n_25 C=n_1 Y=n_88
Xg3586__6417 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[33]
+ B=n_57 C=n_1 Y=n_87
Xg3587__5477 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[34]
+ B=n_12 C=n_1 Y=n_86
Xg3588__2398 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[21]
+ B=n_20 C=n_1 Y=n_85
Xg3589__5107 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[37]
+ B=n_59 C=n_1 Y=n_84
Xg3590__6260 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[38]
+ B=n_21 C=n_1 Y=n_83
Xg3591__4319 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[39]
+ B=n_60 C=n_1 Y=n_82
Xg3592__8428 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[0] A2=n_35
+ B1=register_dataout[3] B2=n_27 Y=n_81
Xg3593__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[15] A2=n_26
+ B1=register_dataout[19] B2=n_27 Y=n_80
Xg3594__6783 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[7] B=n_77 Y=n_107
Xg3595__3680 OAI21xp5_ASAP7_75t_SL $PINS A1=n_62 A2=n_61 B=n_79 Y=n_106
Xg3596__1617 NAND3xp33_ASAP7_75t_SL $PINS A=n_27 B=count_bit[5]
+ C=register_dataout[35] Y=n_105
Xg3597__2802 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[32] A2=n_31
+ B1=register_dataout[36] B2=n_36 Y=n_104
Xg3598__1705 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[33] A2=n_31
+ B1=register_dataout[37] B2=n_36 Y=n_102
Xg3599__5122 NAND2xp5_ASAP7_75t_SL $PINS A=n_5 B=n_75 Y=n_101
Xg3600__8246 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[34] A2=n_31
+ B1=register_dataout[38] B2=n_36 Y=n_100
Xg3601 INVxp67_ASAP7_75t_SL $PINS A=n_78 Y=n_79
Xg3602 INVxp67_ASAP7_75t_SL $PINS A=n_76 Y=n_77
Xg3603 INVx1_ASAP7_75t_SL $PINS A=n_74 Y=n_75
Xg3604__7098 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[17] B=n_26 Y=n_73
Xg3605__6131 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[11] B=n_27 Y=n_72
Xg3606__1881 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[27] B=n_27 Y=n_71
Xg3607__5115 NOR2xp33_ASAP7_75t_SL $PINS A=n_62 B=n_33 Y=n_78
Xg3608__7482 NAND2xp5_ASAP7_75t_SL $PINS A=n_6 B=n_26 Y=n_76
Xg3609__4733 NAND2xp5_ASAP7_75t_SL $PINS A=n_7 B=n_26 Y=n_74
Xg3610 INVxp67_ASAP7_75t_SL $PINS A=n_69 Y=n_70
Xg3611__6161 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[8] A2=n_3
+ B1=register_dataout[12] B2=count_bit[2] Y=n_68
Xg3612__9315 AND3x1_ASAP7_75t_SL $PINS A=n_3 B=n_6 C=register_dataout[1] Y=n_67
Xg3613__9945 NOR3xp33_ASAP7_75t_SL $PINS A=register_dataout[3]
+ B=register_dataout[1] C=register_dataout[0] Y=n_66
Xg3614__2883 OAI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[10]
+ A2=count_bit[2] B1=register_dataout[14] B2=n_3 Y=n_65
Xg3615__2346 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[26] A2=n_3
+ B1=register_dataout[30] B2=count_bit[2] Y=n_64
Xg3616__1666 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[9] A2=n_3
+ B1=register_dataout[13] B2=count_bit[2] Y=n_63
Xg3617__7410 NAND3xp33_ASAP7_75t_SL $PINS A=n_8 B=ready_out C=Frame Y=n_69
Xg3618__6417 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[39] Y=n_60
Xg3619__5477 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[37] Y=n_59
Xg3620__2398 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[17] Y=n_58
Xg3621__5107 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[33] Y=n_57
Xg3622__6260 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[7] Y=n_56
Xg3623__4319 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[32] Y=n_55
Xg3624__8428 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[26] Y=n_54
Xg3625__5526 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[28] Y=n_53
Xg3626__6783 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[29] Y=n_52
Xg3627__3680 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[9] Y=n_51
Xg3628__1617 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[16] Y=n_50
Xg3629__2802 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[35] Y=n_49
Xg3630__1705 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[0] Y=n_48
Xg3631__5122 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[36] Y=n_47
Xg3632__8246 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[19] Y=n_46
Xg3633__7098 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[25] Y=n_45
Xg3634__6131 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[4] Y=n_44
Xg3635__1881 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[30] Y=n_43
Xg3636__5115 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[5] Y=n_42
Xg3637__7482 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[6] Y=n_41
Xg3638__4733 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[18] Y=n_40
Xg3639__6161 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[3] Y=n_39
Xg3640__9315 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[21] B=count_bit[2]
+ Y=n_38
Xg3641__9945 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[20] Y=n_37
Xg3642__2883 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[39] B=count_bit[5]
+ Y=n_62
Xg3643__2346 NAND2xp5_ASAP7_75t_SL $PINS A=count_bit[3] B=count_bit[0] Y=n_61
Xg3644 INVxp67_ASAP7_75t_SL $PINS A=n_33 Y=n_32
Xg3645__1666 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[31] Y=n_25
Xg3646__7410 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[10] Y=n_24
Xg3647__6417 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[15] Y=n_23
Xg3648__5477 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[2] Y=n_22
Xg3649__2398 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[38] Y=n_21
Xg3650__5107 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[21] Y=n_20
Xg3651__6260 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[27] Y=n_19
Xg3652__4319 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[23] Y=n_18
Xg3653__8428 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[14] Y=n_17
Xg3654__5526 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[1] Y=n_16
Xg3655__6783 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[24] Y=n_15
Xg3656__3680 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[8] Y=n_14
Xg3657__1617 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[13] Y=n_13
Xg3658__2802 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[34] Y=n_12
Xg3659__1705 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[11] Y=n_11
Xg3660__5122 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[22] Y=n_10
Xg3661__8246 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[12] Y=n_9
Xg3662__7098 NOR2xp33_ASAP7_75t_SL $PINS A=n_6 B=n_3 Y=n_36
Xg3663__6131 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[2] B=n_4 Y=n_35
Xg3664__1881 NOR2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_3 Y=n_34
Xg3665__5115 NAND2xp5_ASAP7_75t_SL $PINS A=count_bit[3] B=n_4 Y=n_33
Xg3666__7482 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[2] B=n_6 Y=n_31
Xg3667__4733 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[5] B=n_3 Y=n_30
Xg3668__6161 NOR2xp33_ASAP7_75t_SL $PINS A=n_0 B=Clear Y=n_29
Xg3669__9315 NOR2xp33_ASAP7_75t_SL $PINS A=enable_PISO B=Clear Y=n_28
Xg3670__9945 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[0] B=n_3 Y=n_27
Xg3671__2883 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[0] B=count_bit[2] Y=n_26
Xg3672 INVxp67_ASAP7_75t_SL $PINS A=OutReady Y=n_8
Xg3673 INVx1_ASAP7_75t_SL $PINS A=count_bit[1] Y=n_7
Xg3674 INVx1_ASAP7_75t_SL $PINS A=count_bit[5] Y=n_6
Xg3675 INVx1_ASAP7_75t_L $PINS A=count_bit[3] Y=n_5
Xg3676 INVx1_ASAP7_75t_SL $PINS A=count_bit[0] Y=n_4
Xg3677 INVx1_ASAP7_75t_SL $PINS A=count_bit[2] Y=n_3
Xg3678 INVx1_ASAP7_75t_SL $PINS A=register_dataout[18] Y=n_2
Xg3679 INVx1_ASAP7_75t_SL $PINS A=Clear Y=n_1
Xg3680 INVx1_ASAP7_75t_SL $PINS A=enable_PISO Y=n_0
.ENDS

.SUBCKT PISO_1 Sclk Clear Frame enable_PISO InputParallel[39] InputParallel[38]
+ InputParallel[37] InputParallel[36] InputParallel[35] InputParallel[34]
+ InputParallel[33] InputParallel[32] InputParallel[31] InputParallel[30]
+ InputParallel[29] InputParallel[28] InputParallel[27] InputParallel[26]
+ InputParallel[25] InputParallel[24] InputParallel[23] InputParallel[22]
+ InputParallel[21] InputParallel[20] InputParallel[19] InputParallel[18]
+ InputParallel[17] InputParallel[16] InputParallel[15] InputParallel[14]
+ InputParallel[13] InputParallel[12] InputParallel[11] InputParallel[10]
+ InputParallel[9] InputParallel[8] InputParallel[7] InputParallel[6]
+ InputParallel[5] InputParallel[4] InputParallel[3] InputParallel[2]
+ InputParallel[1] InputParallel[0] OutputSerial OutReady
XOutReady_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_167 QN=OutReady
XOutputSerial_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_191 QN=OutputSerial
Xcount_bit_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_181 QN=count_bit[0]
Xcount_bit_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_184 QN=count_bit[1]
Xcount_bit_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_188 QN=count_bit[2]
Xcount_bit_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_177 QN=count_bit[3]
Xcount_bit_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_185 QN=count_bit[4]
Xcount_bit_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_175 QN=count_bit[5]
Xready_out_reg SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=Clear SE=n_28 SI=n_128
+ QN=ready_out
Xregister_dataout_reg[0] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_127
+ QN=register_dataout[0]
Xregister_dataout_reg[1] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_126
+ QN=register_dataout[1]
Xregister_dataout_reg[2] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_125
+ QN=register_dataout[2]
Xregister_dataout_reg[3] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_124
+ QN=register_dataout[3]
Xregister_dataout_reg[4] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_123
+ QN=register_dataout[4]
Xregister_dataout_reg[5] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_122
+ QN=register_dataout[5]
Xregister_dataout_reg[6] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_121
+ QN=register_dataout[6]
Xregister_dataout_reg[7] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_120
+ QN=register_dataout[7]
Xregister_dataout_reg[8] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_132
+ QN=register_dataout[8]
Xregister_dataout_reg[9] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_118
+ QN=register_dataout[9]
Xregister_dataout_reg[10] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_117
+ QN=register_dataout[10]
Xregister_dataout_reg[11] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_116
+ QN=register_dataout[11]
Xregister_dataout_reg[12] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_115
+ QN=register_dataout[12]
Xregister_dataout_reg[13] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_114
+ QN=register_dataout[13]
Xregister_dataout_reg[14] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_113
+ QN=register_dataout[14]
Xregister_dataout_reg[15] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_111
+ QN=register_dataout[15]
Xregister_dataout_reg[16] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_110
+ QN=register_dataout[16]
Xregister_dataout_reg[17] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_112
+ QN=register_dataout[17]
Xregister_dataout_reg[18] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_109
+ QN=register_dataout[18]
Xregister_dataout_reg[19] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_108
+ QN=register_dataout[19]
Xregister_dataout_reg[20] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_119
+ QN=register_dataout[20]
Xregister_dataout_reg[21] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_85
+ QN=register_dataout[21]
Xregister_dataout_reg[22] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_97
+ QN=register_dataout[22]
Xregister_dataout_reg[23] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_96
+ QN=register_dataout[23]
Xregister_dataout_reg[24] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_95
+ QN=register_dataout[24]
Xregister_dataout_reg[25] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_94
+ QN=register_dataout[25]
Xregister_dataout_reg[26] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_93
+ QN=register_dataout[26]
Xregister_dataout_reg[27] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_92
+ QN=register_dataout[27]
Xregister_dataout_reg[28] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_91
+ QN=register_dataout[28]
Xregister_dataout_reg[29] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_90
+ QN=register_dataout[29]
Xregister_dataout_reg[30] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_131
+ QN=register_dataout[30]
Xregister_dataout_reg[31] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_88
+ QN=register_dataout[31]
Xregister_dataout_reg[32] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_129
+ QN=register_dataout[32]
Xregister_dataout_reg[33] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_87
+ QN=register_dataout[33]
Xregister_dataout_reg[34] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_86
+ QN=register_dataout[34]
Xregister_dataout_reg[35] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_98
+ QN=register_dataout[35]
Xregister_dataout_reg[36] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_130
+ QN=register_dataout[36]
Xregister_dataout_reg[37] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_84
+ QN=register_dataout[37]
Xregister_dataout_reg[38] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_83
+ QN=register_dataout[38]
Xregister_dataout_reg[39] DFFHQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_82
+ QN=register_dataout[39]
Xg3441__2346 AOI33xp33_ASAP7_75t_SL $PINS A1=n_163 A2=n_28 A3=n_190 B1=n_162
+ B2=n_1 B3=OutputSerial Y=n_191
Xg3442__1666 AOI31xp33_ASAP7_75t_SL $PINS A1=n_187 A2=n_171 A3=count_bit[4]
+ B=n_189 Y=n_190
Xg3443__7410 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=count_bit[1] A2=n_186 B=n_183
+ C=count_bit[4] Y=n_189
Xg3446__6417 AOI22xp5_ASAP7_75t_SL $PINS A1=n_182 A2=count_bit[2] B1=n_172
+ B2=n_75 Y=n_188
Xg3448__5477 OAI21xp5_ASAP7_75t_SL $PINS A1=n_106 A2=n_173 B=count_bit[1]
+ Y=n_187
Xg3450__2398 OR4x1_ASAP7_75t_SL $PINS A=n_170 B=n_153 C=n_147 D=n_106 Y=n_186
Xg3451__5107 AOI22xp5_ASAP7_75t_SL $PINS A1=n_176 A2=count_bit[4] B1=n_172
+ B2=n_140 Y=n_185
Xg3452__6260 AOI21xp5_ASAP7_75t_SL $PINS A1=count_bit[1] A2=n_179 B=n_180
+ Y=n_184
Xg3453__4319 OR5x1_ASAP7_75t_SL $PINS A=n_160 B=n_146 C=n_142 D=n_78 E=n_7
+ Y=n_183
Xg3456__8428 OAI21xp5_ASAP7_75t_SL $PINS A1=n_166 A2=n_7 B=n_178 Y=n_182
Xg3457__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=n_168 A2=n_1 B1=n_29
+ B2=count_bit[0] Y=n_181
Xg3458__6783 AND3x1_ASAP7_75t_SL $PINS A=n_4 B=n_7 C=n_172 Y=n_180
Xg3459 INVxp67_ASAP7_75t_SL $PINS A=n_178 Y=n_179
Xg3460__3680 OA211x2_ASAP7_75t_SL $PINS A1=n_101 A2=n_162 B=n_137 C=n_169
+ Y=n_177
Xg3461__1617 AOI21xp5_ASAP7_75t_SL $PINS A1=count_bit[0] A2=n_165 B=n_29
+ Y=n_178
Xg3463 INVx1_ASAP7_75t_SL $PINS A=n_174 Y=n_176
Xg3464__2802 OA211x2_ASAP7_75t_SL $PINS A1=n_148 A2=n_162 B=n_152 C=n_169
+ Y=n_175
Xg3465__1705 AOI21xp5_ASAP7_75t_SL $PINS A1=n_101 A2=n_165 B=n_29 Y=n_174
Xg3466__5122 OAI211xp5_ASAP7_75t_SL $PINS A1=count_bit[3] A2=n_157 B=n_149
+ C=n_141 Y=n_173
Xg3467__8246 AOI31xp33_ASAP7_75t_SL $PINS A1=n_158 A2=count_bit[3] A3=n_7
+ B=n_164 Y=n_171
Xg3468__7098 AOI31xp33_ASAP7_75t_SL $PINS A1=n_144 A2=n_150 A3=n_107
+ B=count_bit[3] Y=n_170
Xg3469__6131 NOR2xp33_ASAP7_75t_SL $PINS A=enable_PISO B=n_166 Y=n_172
Xg3470__1881 NOR3xp33_ASAP7_75t_SL $PINS A=n_162 B=count_bit[0] C=n_133 Y=n_168
Xg3471__5115 AOI22xp33_ASAP7_75t_SL $PINS A1=n_159 A2=OutReady B1=n_70 B2=n_28
+ Y=n_167
Xg3472__7482 AOI21xp5_ASAP7_75t_SL $PINS A1=n_161 A2=n_133 B=Clear Y=n_169
Xg3473 INVxp67_ASAP7_75t_SL $PINS A=n_166 Y=n_165
Xg3474__4733 NAND2xp5_ASAP7_75t_SL $PINS A=n_163 B=n_1 Y=n_166
Xg3475__6161 AOI311xp33_ASAP7_75t_SL $PINS A1=n_144 A2=n_89 A3=n_80
+ B=count_bit[1] C=count_bit[3] Y=n_164
Xg3476 INVx1_ASAP7_75t_SL $PINS A=n_162 Y=n_161
Xg3477__9315 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_4 A2=n_135 B=n_134
+ C=count_bit[3] Y=n_160
Xg3478__9945 NOR2xp33_ASAP7_75t_SL $PINS A=n_133 B=n_154 Y=n_163
Xg3479__2883 NAND2xp5_ASAP7_75t_SL $PINS A=n_0 B=n_155 Y=n_162
Xg3480 INVx1_ASAP7_75t_SL $PINS A=n_156 Y=n_159
Xg3481__2346 NAND4xp25_ASAP7_75t_SL $PINS A=n_144 B=n_138 C=n_71 D=n_62 Y=n_158
Xg3482__1666 AOI221xp5_ASAP7_75t_SL $PINS A1=n_136 A2=count_bit[0] B1=n_34
+ B2=register_dataout[22] C=n_151 Y=n_157
Xg3483__7410 AOI21xp5_ASAP7_75t_SL $PINS A1=n_148 A2=n_1 B=n_29 Y=n_156
Xg3484 INVxp67_ASAP7_75t_SL $PINS A=n_154 Y=n_155
Xg3485__6417 AOI31xp33_ASAP7_75t_SL $PINS A1=n_107 A2=n_105 A3=n_72 B=n_5
+ Y=n_153
Xg3486__5477 NOR2xp33_ASAP7_75t_SL $PINS A=n_8 B=n_148 Y=n_154
Xg3488__2398 OAI21xp33_ASAP7_75t_SL $PINS A1=enable_PISO A2=n_139
+ B=count_bit[5] Y=n_152
Xg3489__5107 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_38 A2=n_102 B=count_bit[0]
+ C=n_73 Y=n_151
Xg3490__6260 AOI321xp33_ASAP7_75t_SL $PINS A1=n_30 A2=count_bit[0]
+ A3=register_dataout[4] B1=n_26 B2=register_dataout[31] C=n_143 Y=n_150
Xg3491__4319 AOI31xp33_ASAP7_75t_SL $PINS A1=n_26 A2=count_bit[3]
+ A3=register_dataout[25] B=n_145 Y=n_149
Xg3492__8428 AOI21xp5_ASAP7_75t_SL $PINS A1=n_104 A2=n_68 B=n_61 Y=n_147
Xg3493__5526 AOI31xp33_ASAP7_75t_SL $PINS A1=n_100 A2=n_65 A3=n_62 B=n_61
+ Y=n_146
Xg3494__6783 AOI21xp5_ASAP7_75t_SL $PINS A1=n_100 A2=n_64 B=n_61 Y=n_145
Xg3495__3680 NAND2xp5_ASAP7_75t_SL $PINS A=n_6 B=n_140 Y=n_148
Xg3496__1617 OAI22xp5_ASAP7_75t_SL $PINS A1=count_bit[5] A2=n_81 B1=n_66
+ B2=n_76 Y=n_143
Xg3497__2802 OAI22xp5_ASAP7_75t_SL $PINS A1=count_bit[0] A2=n_102 B1=n_33
+ B2=n_63 Y=n_142
Xg3498__1705 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=register_dataout[29]
+ A2=count_bit[2] B=n_103 C=n_32 Y=n_141
Xg3499__5122 OA21x2_ASAP7_75t_SL $PINS A1=n_4 A2=n_104 B=n_105 Y=n_144
Xg3523 INVxp67_ASAP7_75t_SL $PINS A=n_140 Y=n_139
Xg3524__8246 AOI222xp33_ASAP7_75t_SL $PINS A1=register_dataout[23] A2=n_26
+ B1=n_35 B2=register_dataout[24] C1=register_dataout[28] C2=n_34 Y=n_138
Xg3525__7098 OAI21xp33_ASAP7_75t_SL $PINS A1=enable_PISO A2=n_74 B=count_bit[3]
+ Y=n_137
Xg3526__6131 OAI21xp5_ASAP7_75t_SL $PINS A1=n_2 A2=count_bit[2] B=n_100 Y=n_136
Xg3527__1881 AOI321xp33_ASAP7_75t_SL $PINS A1=n_3 A2=n_6 A3=register_dataout[2]
+ B1=n_30 B2=register_dataout[6] C=n_99 Y=n_135
Xg3528__5115 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=register_dataout[5] A2=n_30
+ B=n_67 C=n_4 Y=n_134
Xg3546__7482 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[4] B=n_101 Y=n_140
Xg3547__4733 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[8]
+ B=n_14 C=n_1 Y=n_132
Xg3548__6161 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[30]
+ B=n_43 C=n_1 Y=n_131
Xg3549__9315 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[36]
+ B=n_47 C=n_1 Y=n_130
Xg3550__9945 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[32]
+ B=n_55 C=n_1 Y=n_129
Xg3551__2883 NAND2xp5_ASAP7_75t_SL $PINS A=n_69 B=ready_out Y=n_128
Xg3552__2346 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[0]
+ B=n_48 C=n_1 Y=n_127
Xg3553__1666 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[1]
+ B=n_16 C=n_1 Y=n_126
Xg3554__7410 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[2]
+ B=n_22 C=n_1 Y=n_125
Xg3555__6417 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[3]
+ B=n_39 C=n_1 Y=n_124
Xg3556__5477 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[4]
+ B=n_44 C=n_1 Y=n_123
Xg3557__2398 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[5]
+ B=n_42 C=n_1 Y=n_122
Xg3558__5107 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[6]
+ B=n_41 C=n_1 Y=n_121
Xg3559__6260 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[7]
+ B=n_56 C=n_1 Y=n_120
Xg3560__4319 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[20]
+ B=n_37 C=n_1 Y=n_119
Xg3561__8428 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[9]
+ B=n_51 C=n_1 Y=n_118
Xg3562__5526 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[10]
+ B=n_24 C=n_1 Y=n_117
Xg3563__6783 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[11]
+ B=n_11 C=n_1 Y=n_116
Xg3564__3680 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[12]
+ B=n_9 C=n_1 Y=n_115
Xg3565__1617 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[13]
+ B=n_13 C=n_1 Y=n_114
Xg3566__2802 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[14]
+ B=n_17 C=n_1 Y=n_113
Xg3567__1705 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[17]
+ B=n_58 C=n_1 Y=n_112
Xg3568__5122 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[15]
+ B=n_23 C=n_1 Y=n_111
Xg3569__8246 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[16]
+ B=n_50 C=n_1 Y=n_110
Xg3570__7098 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[18]
+ B=n_40 C=n_1 Y=n_109
Xg3571__6131 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[19]
+ B=n_46 C=n_1 Y=n_108
Xg3572__1881 NOR2xp33_ASAP7_75t_SL $PINS A=n_70 B=OutReady Y=n_133
Xg3573 INVxp67_ASAP7_75t_SL $PINS A=n_102 Y=n_103
Xg3574 INVx1_ASAP7_75t_SL $PINS A=n_100 Y=n_99
Xg3575__5115 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[35]
+ B=n_49 C=n_1 Y=n_98
Xg3576__7482 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[22]
+ B=n_10 C=n_1 Y=n_97
Xg3577__4733 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[23]
+ B=n_18 C=n_1 Y=n_96
Xg3578__6161 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[24]
+ B=n_15 C=n_1 Y=n_95
Xg3579__9315 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[25]
+ B=n_45 C=n_1 Y=n_94
Xg3580__9945 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[26]
+ B=n_54 C=n_1 Y=n_93
Xg3581__2883 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[27]
+ B=n_19 C=n_1 Y=n_92
Xg3582__2346 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[28]
+ B=n_53 C=n_1 Y=n_91
Xg3583__1666 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[29]
+ B=n_52 C=n_1 Y=n_90
Xg3584__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[16] A2=n_35
+ B1=register_dataout[20] B2=n_34 Y=n_89
Xg3585__6417 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[31]
+ B=n_25 C=n_1 Y=n_88
Xg3586__5477 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[33]
+ B=n_57 C=n_1 Y=n_87
Xg3587__2398 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[34]
+ B=n_12 C=n_1 Y=n_86
Xg3588__5107 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[21]
+ B=n_20 C=n_1 Y=n_85
Xg3589__6260 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[37]
+ B=n_59 C=n_1 Y=n_84
Xg3590__4319 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[38]
+ B=n_21 C=n_1 Y=n_83
Xg3591__8428 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_0 A2=register_dataout[39]
+ B=n_60 C=n_1 Y=n_82
Xg3592__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[0] A2=n_35
+ B1=register_dataout[3] B2=n_27 Y=n_81
Xg3593__6783 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[15] A2=n_26
+ B1=register_dataout[19] B2=n_27 Y=n_80
Xg3594__3680 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[7] B=n_77 Y=n_107
Xg3595__1617 OAI21xp5_ASAP7_75t_SL $PINS A1=n_62 A2=n_61 B=n_79 Y=n_106
Xg3596__2802 NAND3xp33_ASAP7_75t_SL $PINS A=n_27 B=count_bit[5]
+ C=register_dataout[35] Y=n_105
Xg3597__1705 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[32] A2=n_31
+ B1=register_dataout[36] B2=n_36 Y=n_104
Xg3598__5122 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[33] A2=n_31
+ B1=register_dataout[37] B2=n_36 Y=n_102
Xg3599__8246 NAND2xp5_ASAP7_75t_SL $PINS A=n_5 B=n_75 Y=n_101
Xg3600__7098 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[34] A2=n_31
+ B1=register_dataout[38] B2=n_36 Y=n_100
Xg3601 INVxp67_ASAP7_75t_SL $PINS A=n_78 Y=n_79
Xg3602 INVxp67_ASAP7_75t_SL $PINS A=n_76 Y=n_77
Xg3603 INVx1_ASAP7_75t_SL $PINS A=n_74 Y=n_75
Xg3604__6131 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[17] B=n_26 Y=n_73
Xg3605__1881 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[11] B=n_27 Y=n_72
Xg3606__5115 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[27] B=n_27 Y=n_71
Xg3607__7482 NOR2xp33_ASAP7_75t_SL $PINS A=n_62 B=n_33 Y=n_78
Xg3608__4733 NAND2xp5_ASAP7_75t_SL $PINS A=n_6 B=n_26 Y=n_76
Xg3609__6161 NAND2xp5_ASAP7_75t_SL $PINS A=n_7 B=n_26 Y=n_74
Xg3610 INVx1_ASAP7_75t_SL $PINS A=n_69 Y=n_70
Xg3611__9315 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[8] A2=n_3
+ B1=register_dataout[12] B2=count_bit[2] Y=n_68
Xg3612__9945 AND3x1_ASAP7_75t_SL $PINS A=n_3 B=n_6 C=register_dataout[1] Y=n_67
Xg3613__2883 NOR3xp33_ASAP7_75t_SL $PINS A=register_dataout[3]
+ B=register_dataout[1] C=register_dataout[0] Y=n_66
Xg3614__2346 OAI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[10]
+ A2=count_bit[2] B1=register_dataout[14] B2=n_3 Y=n_65
Xg3615__1666 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[26] A2=n_3
+ B1=register_dataout[30] B2=count_bit[2] Y=n_64
Xg3616__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=register_dataout[9] A2=n_3
+ B1=register_dataout[13] B2=count_bit[2] Y=n_63
Xg3617__6417 NAND3xp33_ASAP7_75t_SL $PINS A=n_8 B=ready_out C=Frame Y=n_69
Xg3618__5477 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[39] Y=n_60
Xg3619__2398 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[37] Y=n_59
Xg3620__5107 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[17] Y=n_58
Xg3621__6260 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[33] Y=n_57
Xg3622__4319 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[7] Y=n_56
Xg3623__8428 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[32] Y=n_55
Xg3624__5526 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[26] Y=n_54
Xg3625__6783 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[28] Y=n_53
Xg3626__3680 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[29] Y=n_52
Xg3627__1617 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[9] Y=n_51
Xg3628__2802 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[16] Y=n_50
Xg3629__1705 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[35] Y=n_49
Xg3630__5122 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[0] Y=n_48
Xg3631__8246 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[36] Y=n_47
Xg3632__7098 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[19] Y=n_46
Xg3633__6131 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[25] Y=n_45
Xg3634__1881 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[4] Y=n_44
Xg3635__5115 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[30] Y=n_43
Xg3636__7482 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[5] Y=n_42
Xg3637__4733 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[6] Y=n_41
Xg3638__6161 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[18] Y=n_40
Xg3639__9315 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[3] Y=n_39
Xg3640__9945 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[21] B=count_bit[2]
+ Y=n_38
Xg3641__2883 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[20] Y=n_37
Xg3642__2346 NAND2xp5_ASAP7_75t_SL $PINS A=register_dataout[39] B=count_bit[5]
+ Y=n_62
Xg3643__1666 NAND2xp5_ASAP7_75t_SL $PINS A=count_bit[3] B=count_bit[0] Y=n_61
Xg3644 INVxp67_ASAP7_75t_SL $PINS A=n_33 Y=n_32
Xg3645__7410 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[31] Y=n_25
Xg3646__6417 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[10] Y=n_24
Xg3647__5477 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[15] Y=n_23
Xg3648__2398 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[2] Y=n_22
Xg3649__5107 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[38] Y=n_21
Xg3650__6260 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[21] Y=n_20
Xg3651__4319 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[27] Y=n_19
Xg3652__8428 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[23] Y=n_18
Xg3653__5526 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[14] Y=n_17
Xg3654__6783 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[1] Y=n_16
Xg3655__3680 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[24] Y=n_15
Xg3656__1617 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[8] Y=n_14
Xg3657__2802 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[13] Y=n_13
Xg3658__1705 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[34] Y=n_12
Xg3659__5122 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[11] Y=n_11
Xg3660__8246 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[22] Y=n_10
Xg3661__7098 AND2x2_ASAP7_75t_SL $PINS A=enable_PISO B=InputParallel[12] Y=n_9
Xg3662__6131 NOR2xp33_ASAP7_75t_SL $PINS A=n_6 B=n_3 Y=n_36
Xg3663__1881 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[2] B=n_4 Y=n_35
Xg3664__5115 NOR2xp33_ASAP7_75t_SL $PINS A=n_4 B=n_3 Y=n_34
Xg3665__7482 NAND2xp5_ASAP7_75t_SL $PINS A=count_bit[3] B=n_4 Y=n_33
Xg3666__4733 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[2] B=n_6 Y=n_31
Xg3667__6161 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[5] B=n_3 Y=n_30
Xg3668__9315 NOR2xp33_ASAP7_75t_SL $PINS A=n_0 B=Clear Y=n_29
Xg3669__9945 NOR2xp33_ASAP7_75t_SL $PINS A=enable_PISO B=Clear Y=n_28
Xg3670__2883 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[0] B=n_3 Y=n_27
Xg3671__2346 NOR2xp33_ASAP7_75t_SL $PINS A=count_bit[0] B=count_bit[2] Y=n_26
Xg3672 INVxp67_ASAP7_75t_SL $PINS A=OutReady Y=n_8
Xg3673 INVx1_ASAP7_75t_SL $PINS A=count_bit[1] Y=n_7
Xg3674 INVx1_ASAP7_75t_SL $PINS A=count_bit[5] Y=n_6
Xg3675 INVx1_ASAP7_75t_L $PINS A=count_bit[3] Y=n_5
Xg3676 INVx1_ASAP7_75t_SL $PINS A=count_bit[0] Y=n_4
Xg3677 INVx1_ASAP7_75t_SL $PINS A=count_bit[2] Y=n_3
Xg3678 INVx1_ASAP7_75t_SL $PINS A=register_dataout[18] Y=n_2
Xg3679 INVx1_ASAP7_75t_SL $PINS A=Clear Y=n_1
Xg3680 INVx1_ASAP7_75t_SL $PINS A=enable_PISO Y=n_0
.ENDS

.SUBCKT R_MEM write_enable read_enable Sclk Frame Write_Address[3]
+ Write_Address[2] Write_Address[1] Write_Address[0] Read_Address[3]
+ Read_Address[2] Read_Address[1] Read_Address[0] data_in[15] data_in[14]
+ data_in[13] data_in[12] data_in[11] data_in[10] data_in[9] data_in[8]
+ data_in[7] data_in[6] data_in[5] data_in[4] data_in[3] data_in[2] data_in[1]
+ data_in[0] Rj[15] Rj[14] Rj[13] Rj[12] Rj[11] Rj[10] Rj[9] Rj[8] Rj[7] Rj[6]
+ Rj[5] Rj[4] Rj[3] Rj[2] Rj[1] Rj[0]
*.CONNECT Rj[8] VSS
*.CONNECT Rj[9] VSS
*.CONNECT Rj[10] VSS
*.CONNECT Rj[11] VSS
*.CONNECT Rj[12] VSS
*.CONNECT Rj[13] VSS
*.CONNECT Rj[14] VSS
*.CONNECT Rj[15] VSS
Xmem_0_0 SRAM2RW16x8 $PINS CE1=Sclk CE2=VDD WEB1=mem_0_0_WEB1 WEB2=VDD
+ OEB1=mem_0_0_OEB1 OEB2=VDD CSB1=mem_0_0_CSB1 CSB2=VDD A1[3]=RW0_addr[3]
+ A1[2]=RW0_addr[2] A1[1]=RW0_addr[1] A1[0]=RW0_addr[0] A2[3]=RW0_addr[3]
+ A2[2]=RW0_addr[2] A2[1]=RW0_addr[1] A2[0]=RW0_addr[0] I1[7]=data_in[7]
+ I1[6]=data_in[6] I1[5]=data_in[5] I1[4]=data_in[4] I1[3]=data_in[3]
+ I1[2]=data_in[2] I1[1]=data_in[1] I1[0]=data_in[0] I2[7]=data_in[7]
+ I2[6]=data_in[6] I2[5]=data_in[5] I2[4]=data_in[4] I2[3]=data_in[3]
+ I2[2]=data_in[2] I2[1]=data_in[1] I2[0]=data_in[0] O1[7]=Rj[7] O1[6]=Rj[6]
+ O1[5]=Rj[5] O1[4]=Rj[4] O1[3]=Rj[3] O1[2]=Rj[2] O1[1]=Rj[1] O1[0]=Rj[0]
+ O2[7]=mem_0_0_O2[7] O2[6]=mem_0_0_O2[6] O2[5]=mem_0_0_O2[5] O2[4]=mem_0_0_O2[4]
+ O2[3]=mem_0_0_O2[3] O2[2]=mem_0_0_O2[2] O2[1]=mem_0_0_O2[1] O2[0]=mem_0_0_O2[0]
Xg125__1666 NAND2xp33_ASAP7_75t_SL $PINS A=n_2 B=mem_0_0_WEB1 Y=mem_0_0_OEB1
Xg126__7410 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg127__6417 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg128__5477 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg129__2398 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg130__5107 NAND2xp5_ASAP7_75t_SL $PINS A=Frame B=write_enable Y=mem_0_0_WEB1
Xg131 INVx1_ASAP7_75t_L $PINS A=n_1 Y=n_2
Xg132__6260 NOR2xp33_ASAP7_75t_SL $PINS A=read_enable B=write_enable Y=n_1
Xg133 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
Xdrc_bufs136 BUFx2_ASAP7_75t_L $PINS A=n_1 Y=mem_0_0_CSB1
.ENDS

.SUBCKT R_MEM_1 write_enable read_enable Sclk Frame Write_Address[3]
+ Write_Address[2] Write_Address[1] Write_Address[0] Read_Address[3]
+ Read_Address[2] Read_Address[1] Read_Address[0] data_in[15] data_in[14]
+ data_in[13] data_in[12] data_in[11] data_in[10] data_in[9] data_in[8]
+ data_in[7] data_in[6] data_in[5] data_in[4] data_in[3] data_in[2] data_in[1]
+ data_in[0] Rj[15] Rj[14] Rj[13] Rj[12] Rj[11] Rj[10] Rj[9] Rj[8] Rj[7] Rj[6]
+ Rj[5] Rj[4] Rj[3] Rj[2] Rj[1] Rj[0]
*.CONNECT Rj[8] VSS
*.CONNECT Rj[9] VSS
*.CONNECT Rj[10] VSS
*.CONNECT Rj[11] VSS
*.CONNECT Rj[12] VSS
*.CONNECT Rj[13] VSS
*.CONNECT Rj[14] VSS
*.CONNECT Rj[15] VSS
Xmem_0_0 SRAM2RW16x8 $PINS CE1=Sclk CE2=VDD WEB1=mem_0_0_WEB1 WEB2=VDD
+ OEB1=mem_0_0_OEB1 OEB2=VDD CSB1=mem_0_0_CSB1 CSB2=VDD A1[3]=RW0_addr[3]
+ A1[2]=RW0_addr[2] A1[1]=RW0_addr[1] A1[0]=RW0_addr[0] A2[3]=RW0_addr[3]
+ A2[2]=RW0_addr[2] A2[1]=RW0_addr[1] A2[0]=RW0_addr[0] I1[7]=data_in[7]
+ I1[6]=data_in[6] I1[5]=data_in[5] I1[4]=data_in[4] I1[3]=data_in[3]
+ I1[2]=data_in[2] I1[1]=data_in[1] I1[0]=data_in[0] I2[7]=data_in[7]
+ I2[6]=data_in[6] I2[5]=data_in[5] I2[4]=data_in[4] I2[3]=data_in[3]
+ I2[2]=data_in[2] I2[1]=data_in[1] I2[0]=data_in[0] O1[7]=Rj[7] O1[6]=Rj[6]
+ O1[5]=Rj[5] O1[4]=Rj[4] O1[3]=Rj[3] O1[2]=Rj[2] O1[1]=Rj[1] O1[0]=Rj[0]
+ O2[7]=mem_0_0_O2[7] O2[6]=mem_0_0_O2[6] O2[5]=mem_0_0_O2[5] O2[4]=mem_0_0_O2[4]
+ O2[3]=mem_0_0_O2[3] O2[2]=mem_0_0_O2[2] O2[1]=mem_0_0_O2[1] O2[0]=mem_0_0_O2[0]
Xg125__4319 NAND2xp33_ASAP7_75t_SL $PINS A=n_2 B=mem_0_0_WEB1 Y=mem_0_0_OEB1
Xg126__8428 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[1] A2=n_0
+ B1=Write_Address[1] B2=write_enable Y=RW0_addr[1]
Xg127__5526 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[0] A2=n_0
+ B1=Write_Address[0] B2=write_enable Y=RW0_addr[0]
Xg128__6783 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[3] A2=n_0
+ B1=Write_Address[3] B2=write_enable Y=RW0_addr[3]
Xg129__3680 AO22x1_ASAP7_75t_SL $PINS A1=Read_Address[2] A2=n_0
+ B1=Write_Address[2] B2=write_enable Y=RW0_addr[2]
Xg130__1617 NAND2xp5_ASAP7_75t_SL $PINS A=Frame B=write_enable Y=mem_0_0_WEB1
Xg131 INVx1_ASAP7_75t_L $PINS A=n_1 Y=n_2
Xg132__2802 NOR2xp33_ASAP7_75t_SL $PINS A=read_enable B=write_enable Y=n_1
Xg133 INVx1_ASAP7_75t_SL $PINS A=write_enable Y=n_0
Xdrc_bufs136 BUFx2_ASAP7_75t_L $PINS A=n_1 Y=mem_0_0_CSB1
.ENDS

.SUBCKT adder input1[39] input1[38] input1[37] input1[36] input1[35] input1[34]
+ input1[33] input1[32] input1[31] input1[30] input1[29] input1[28] input1[27]
+ input1[26] input1[25] input1[24] input1[23] input1[22] input1[21] input1[20]
+ input1[19] input1[18] input1[17] input1[16] input1[15] input1[14] input1[13]
+ input1[12] input1[11] input1[10] input1[9] input1[8] input1[7] input1[6]
+ input1[5] input1[4] input1[3] input1[2] input1[1] input1[0] input2[39]
+ input2[38] input2[37] input2[36] input2[35] input2[34] input2[33] input2[32]
+ input2[31] input2[30] input2[29] input2[28] input2[27] input2[26] input2[25]
+ input2[24] input2[23] input2[22] input2[21] input2[20] input2[19] input2[18]
+ input2[17] input2[16] input2[15] input2[14] input2[13] input2[12] input2[11]
+ input2[10] input2[9] input2[8] input2[7] input2[6] input2[5] input2[4]
+ input2[3] input2[2] input2[1] input2[0] op out[39] out[38] out[37] out[36]
+ out[35] out[34] out[33] out[32] out[31] out[30] out[29] out[28] out[27]
+ out[26] out[25] out[24] out[23] out[22] out[21] out[20] out[19] out[18]
+ out[17] out[16] out[15] out[14] out[13] out[12] out[11] out[10] out[9] out[8]
+ out[7] out[6] out[5] out[4] out[3] out[2] out[1] out[0]
*.CONNECT out[0] VSS
*.CONNECT out[1] VSS
*.CONNECT out[2] VSS
*.CONNECT out[3] VSS
*.CONNECT out[4] VSS
*.CONNECT out[5] VSS
*.CONNECT out[6] VSS
*.CONNECT out[7] VSS
*.CONNECT out[8] VSS
*.CONNECT out[9] VSS
*.CONNECT out[10] VSS
*.CONNECT out[11] VSS
*.CONNECT out[12] VSS
*.CONNECT out[13] VSS
*.CONNECT out[14] VSS
*.CONNECT out[15] VSS
Xsub_6_75_Y_add_6_39_g827__1705 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_40 B=sub_6_75_Y_add_6_39_n_100 Y=out[39]
Xsub_6_75_Y_add_6_39_g828__5122 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_42 B=sub_6_75_Y_add_6_39_n_97 Y=out[38]
Xsub_6_75_Y_add_6_39_g829__8246 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_98 B=sub_6_75_Y_add_6_39_n_15 C=input2[38]
+ Y=sub_6_75_Y_add_6_39_n_100
Xsub_6_75_Y_add_6_39_g830__7098 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_41 B=sub_6_75_Y_add_6_39_n_94 Y=out[37]
Xsub_6_75_Y_add_6_39_g831 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_97
+ Y=sub_6_75_Y_add_6_39_n_98
Xsub_6_75_Y_add_6_39_g832__6131 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_95 B=sub_6_75_Y_add_6_39_n_15 C=input2[37]
+ Y=sub_6_75_Y_add_6_39_n_97
Xsub_6_75_Y_add_6_39_g833__1881 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_39 B=sub_6_75_Y_add_6_39_n_91 Y=out[36]
Xsub_6_75_Y_add_6_39_g834 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_94
+ Y=sub_6_75_Y_add_6_39_n_95
Xsub_6_75_Y_add_6_39_g835__5115 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_92 B=sub_6_75_Y_add_6_39_n_15 C=input2[36]
+ Y=sub_6_75_Y_add_6_39_n_94
Xsub_6_75_Y_add_6_39_g836__7482 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_38 B=sub_6_75_Y_add_6_39_n_88 Y=out[35]
Xsub_6_75_Y_add_6_39_g837 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_91
+ Y=sub_6_75_Y_add_6_39_n_92
Xsub_6_75_Y_add_6_39_g838__4733 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_89 B=sub_6_75_Y_add_6_39_n_15 C=input2[35]
+ Y=sub_6_75_Y_add_6_39_n_91
Xsub_6_75_Y_add_6_39_g839__6161 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_37 B=sub_6_75_Y_add_6_39_n_85 Y=out[34]
Xsub_6_75_Y_add_6_39_g840 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_88
+ Y=sub_6_75_Y_add_6_39_n_89
Xsub_6_75_Y_add_6_39_g841__9315 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_86 B=sub_6_75_Y_add_6_39_n_15 C=input2[34]
+ Y=sub_6_75_Y_add_6_39_n_88
Xsub_6_75_Y_add_6_39_g842__9945 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_36 B=sub_6_75_Y_add_6_39_n_82 Y=out[33]
Xsub_6_75_Y_add_6_39_g843 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_85
+ Y=sub_6_75_Y_add_6_39_n_86
Xsub_6_75_Y_add_6_39_g844__2883 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_83 B=sub_6_75_Y_add_6_39_n_15 C=input2[33]
+ Y=sub_6_75_Y_add_6_39_n_85
Xsub_6_75_Y_add_6_39_g845__2346 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_35 B=sub_6_75_Y_add_6_39_n_80 Y=out[32]
Xsub_6_75_Y_add_6_39_g846 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_82
+ Y=sub_6_75_Y_add_6_39_n_83
Xsub_6_75_Y_add_6_39_g847__1666 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_81 B=sub_6_75_Y_add_6_39_n_15 C=input2[32]
+ Y=sub_6_75_Y_add_6_39_n_82
Xsub_6_75_Y_add_6_39_g849 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_80
+ Y=sub_6_75_Y_add_6_39_n_81
Xsub_6_75_Y_add_6_39_g850__7410 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_78 B=sub_6_75_Y_add_6_39_n_15 C=input2[31]
+ Y=sub_6_75_Y_add_6_39_n_80
Xsub_6_75_Y_add_6_39_g851__6417 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_33 B=sub_6_75_Y_add_6_39_n_77 Y=out[30]
Xsub_6_75_Y_add_6_39_g853__5477 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_77 B=sub_6_75_Y_add_6_39_n_23
+ C=sub_6_75_Y_add_6_39_n_10 Y=sub_6_75_Y_add_6_39_n_78
Xsub_6_75_Y_add_6_39_g855__2398 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_75 B=sub_6_75_Y_add_6_39_n_29 C=input2[29]
+ Y=sub_6_75_Y_add_6_39_n_77
Xsub_6_75_Y_add_6_39_g856__5107 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_31 B=sub_6_75_Y_add_6_39_n_74 Y=out[28]
Xsub_6_75_Y_add_6_39_g858__6260 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_74 B=sub_6_75_Y_add_6_39_n_27 C=sub_6_75_Y_add_6_39_n_8
+ Y=sub_6_75_Y_add_6_39_n_75
Xsub_6_75_Y_add_6_39_g860__4319 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_72 B=sub_6_75_Y_add_6_39_n_24 C=input2[27]
+ Y=sub_6_75_Y_add_6_39_n_74
Xsub_6_75_Y_add_6_39_g861__8428 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_55 B=sub_6_75_Y_add_6_39_n_71 Y=out[26]
Xsub_6_75_Y_add_6_39_g863__5526 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_71 B=sub_6_75_Y_add_6_39_n_21
+ C=sub_6_75_Y_add_6_39_n_13 Y=sub_6_75_Y_add_6_39_n_72
Xsub_6_75_Y_add_6_39_g865__6783 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_69 B=sub_6_75_Y_add_6_39_n_17 C=input2[25]
+ Y=sub_6_75_Y_add_6_39_n_71
Xsub_6_75_Y_add_6_39_g866__3680 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_53 B=sub_6_75_Y_add_6_39_n_68 Y=out[24]
Xsub_6_75_Y_add_6_39_g868__1617 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_68 B=sub_6_75_Y_add_6_39_n_18 C=sub_6_75_Y_add_6_39_n_9
+ Y=sub_6_75_Y_add_6_39_n_69
Xsub_6_75_Y_add_6_39_g870__2802 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_66 B=sub_6_75_Y_add_6_39_n_26 C=input2[23]
+ Y=sub_6_75_Y_add_6_39_n_68
Xsub_6_75_Y_add_6_39_g871__1705 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_51 B=sub_6_75_Y_add_6_39_n_65 Y=out[22]
Xsub_6_75_Y_add_6_39_g873__5122 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_65 B=sub_6_75_Y_add_6_39_n_16
+ C=sub_6_75_Y_add_6_39_n_14 Y=sub_6_75_Y_add_6_39_n_66
Xsub_6_75_Y_add_6_39_g875__8246 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_63 B=sub_6_75_Y_add_6_39_n_30 C=input2[21]
+ Y=sub_6_75_Y_add_6_39_n_65
Xsub_6_75_Y_add_6_39_g876__7098 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_49 B=sub_6_75_Y_add_6_39_n_62 Y=out[20]
Xsub_6_75_Y_add_6_39_g878__6131 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_12 B=sub_6_75_Y_add_6_39_n_25
+ C=sub_6_75_Y_add_6_39_n_62 Y=sub_6_75_Y_add_6_39_n_63
Xsub_6_75_Y_add_6_39_g880__1881 MAJIxp5_ASAP7_75t_SL $PINS A=input2[19]
+ B=sub_6_75_Y_add_6_39_n_20 C=sub_6_75_Y_add_6_39_n_60
+ Y=sub_6_75_Y_add_6_39_n_62
Xsub_6_75_Y_add_6_39_g881__5115 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_47 B=sub_6_75_Y_add_6_39_n_57 Y=out[18]
Xsub_6_75_Y_add_6_39_g883__7482 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_11 B=sub_6_75_Y_add_6_39_n_19
+ C=sub_6_75_Y_add_6_39_n_57 Y=sub_6_75_Y_add_6_39_n_60
Xsub_6_75_Y_add_6_39_g884__4733 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_43 B=sub_6_75_Y_add_6_39_n_46 Y=out[17]
Xsub_6_75_Y_add_6_39_g885__6161 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_45 B=op Y=out[16]
Xsub_6_75_Y_add_6_39_g886__9315 MAJIxp5_ASAP7_75t_SL $PINS A=input2[17]
+ B=sub_6_75_Y_add_6_39_n_28 C=sub_6_75_Y_add_6_39_n_44
+ Y=sub_6_75_Y_add_6_39_n_57
Xsub_6_75_Y_add_6_39_g887__9945 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_30 B=input2[21] Y=sub_6_75_Y_add_6_39_n_56
Xsub_6_75_Y_add_6_39_g888__2883 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_21 B=sub_6_75_Y_add_6_39_n_13
+ Y=sub_6_75_Y_add_6_39_n_55
Xsub_6_75_Y_add_6_39_g889__2346 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_17 B=input2[25] Y=sub_6_75_Y_add_6_39_n_54
Xsub_6_75_Y_add_6_39_g890__1666 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_18 B=input2[24] Y=sub_6_75_Y_add_6_39_n_53
Xsub_6_75_Y_add_6_39_g891__7410 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_26 B=input2[23] Y=sub_6_75_Y_add_6_39_n_52
Xsub_6_75_Y_add_6_39_g892__6417 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_16 B=sub_6_75_Y_add_6_39_n_14
+ Y=sub_6_75_Y_add_6_39_n_51
Xsub_6_75_Y_add_6_39_g893__5477 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_24 B=input2[27] Y=sub_6_75_Y_add_6_39_n_50
Xsub_6_75_Y_add_6_39_g894__2398 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_25 B=sub_6_75_Y_add_6_39_n_12
+ Y=sub_6_75_Y_add_6_39_n_49
Xsub_6_75_Y_add_6_39_g895__5107 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_20 B=input2[19] Y=sub_6_75_Y_add_6_39_n_48
Xsub_6_75_Y_add_6_39_g896__6260 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_19 B=sub_6_75_Y_add_6_39_n_11
+ Y=sub_6_75_Y_add_6_39_n_47
Xsub_6_75_Y_add_6_39_g897__4319 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_28 B=input2[17] Y=sub_6_75_Y_add_6_39_n_46
Xsub_6_75_Y_add_6_39_g898__8428 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_22 B=input2[16] Y=sub_6_75_Y_add_6_39_n_45
Xsub_6_75_Y_add_6_39_g899 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_43
+ Y=sub_6_75_Y_add_6_39_n_44
Xsub_6_75_Y_add_6_39_g900__5526 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[38] Y=sub_6_75_Y_add_6_39_n_42
Xsub_6_75_Y_add_6_39_g901__6783 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[37] Y=sub_6_75_Y_add_6_39_n_41
Xsub_6_75_Y_add_6_39_g902__3680 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[39] Y=sub_6_75_Y_add_6_39_n_40
Xsub_6_75_Y_add_6_39_g903__1617 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[36] Y=sub_6_75_Y_add_6_39_n_39
Xsub_6_75_Y_add_6_39_g904__2802 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[35] Y=sub_6_75_Y_add_6_39_n_38
Xsub_6_75_Y_add_6_39_g905__1705 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[34] Y=sub_6_75_Y_add_6_39_n_37
Xsub_6_75_Y_add_6_39_g906__5122 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[33] Y=sub_6_75_Y_add_6_39_n_36
Xsub_6_75_Y_add_6_39_g907__8246 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[32] Y=sub_6_75_Y_add_6_39_n_35
Xsub_6_75_Y_add_6_39_g908__7098 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[31] Y=sub_6_75_Y_add_6_39_n_34
Xsub_6_75_Y_add_6_39_g909__6131 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_23 B=sub_6_75_Y_add_6_39_n_10
+ Y=sub_6_75_Y_add_6_39_n_33
Xsub_6_75_Y_add_6_39_g910__1881 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_29 B=input2[29] Y=sub_6_75_Y_add_6_39_n_32
Xsub_6_75_Y_add_6_39_g911__5115 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_27 B=input2[28] Y=sub_6_75_Y_add_6_39_n_31
Xsub_6_75_Y_add_6_39_g912__7482 MAJIxp5_ASAP7_75t_SL $PINS A=op
+ B=sub_6_75_Y_add_6_39_n_22 C=input2[16] Y=sub_6_75_Y_add_6_39_n_43
Xsub_6_75_Y_add_6_39_g913__4733 XOR2xp5_ASAP7_75t_SL $PINS A=input1[21] B=op
+ Y=sub_6_75_Y_add_6_39_n_30
Xsub_6_75_Y_add_6_39_g914__6161 XOR2xp5_ASAP7_75t_SL $PINS A=input1[29] B=op
+ Y=sub_6_75_Y_add_6_39_n_29
Xsub_6_75_Y_add_6_39_g915__9315 XOR2xp5_ASAP7_75t_SL $PINS A=input1[17] B=op
+ Y=sub_6_75_Y_add_6_39_n_28
Xsub_6_75_Y_add_6_39_g916__9945 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[28] B=op
+ Y=sub_6_75_Y_add_6_39_n_27
Xsub_6_75_Y_add_6_39_g917__2883 XOR2xp5_ASAP7_75t_SL $PINS A=input1[23] B=op
+ Y=sub_6_75_Y_add_6_39_n_26
Xsub_6_75_Y_add_6_39_g918__2346 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[20] B=op
+ Y=sub_6_75_Y_add_6_39_n_25
Xsub_6_75_Y_add_6_39_g919__1666 XOR2xp5_ASAP7_75t_SL $PINS A=input1[27] B=op
+ Y=sub_6_75_Y_add_6_39_n_24
Xsub_6_75_Y_add_6_39_g920__7410 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[30] B=op
+ Y=sub_6_75_Y_add_6_39_n_23
Xsub_6_75_Y_add_6_39_g921__6417 XOR2xp5_ASAP7_75t_SL $PINS A=input1[16] B=op
+ Y=sub_6_75_Y_add_6_39_n_22
Xsub_6_75_Y_add_6_39_g922__5477 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[26] B=op
+ Y=sub_6_75_Y_add_6_39_n_21
Xsub_6_75_Y_add_6_39_g923__2398 XOR2xp5_ASAP7_75t_SL $PINS A=input1[19] B=op
+ Y=sub_6_75_Y_add_6_39_n_20
Xsub_6_75_Y_add_6_39_g924__5107 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[18] B=op
+ Y=sub_6_75_Y_add_6_39_n_19
Xsub_6_75_Y_add_6_39_g925__6260 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[24] B=op
+ Y=sub_6_75_Y_add_6_39_n_18
Xsub_6_75_Y_add_6_39_g926__4319 XOR2xp5_ASAP7_75t_SL $PINS A=input1[25] B=op
+ Y=sub_6_75_Y_add_6_39_n_17
Xsub_6_75_Y_add_6_39_g927__8428 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[22] B=op
+ Y=sub_6_75_Y_add_6_39_n_16
Xsub_6_75_Y_add_6_39_g928__5526 XOR2x1_ASAP7_75t_SL $PINS A=input1[31] B=op
+ Y=sub_6_75_Y_add_6_39_n_15
Xsub_6_75_Y_add_6_39_g929 INVx1_ASAP7_75t_SL $PINS A=input2[22]
+ Y=sub_6_75_Y_add_6_39_n_14
Xsub_6_75_Y_add_6_39_g930 INVx1_ASAP7_75t_SL $PINS A=input2[26]
+ Y=sub_6_75_Y_add_6_39_n_13
Xsub_6_75_Y_add_6_39_g931 INVx1_ASAP7_75t_SL $PINS A=input2[20]
+ Y=sub_6_75_Y_add_6_39_n_12
Xsub_6_75_Y_add_6_39_g932 INVx1_ASAP7_75t_SL $PINS A=input2[18]
+ Y=sub_6_75_Y_add_6_39_n_11
Xsub_6_75_Y_add_6_39_g933 INVx1_ASAP7_75t_SL $PINS A=input2[30]
+ Y=sub_6_75_Y_add_6_39_n_10
Xsub_6_75_Y_add_6_39_g934 INVx1_ASAP7_75t_SL $PINS A=input2[24]
+ Y=sub_6_75_Y_add_6_39_n_9
Xsub_6_75_Y_add_6_39_g935 INVx1_ASAP7_75t_SL $PINS A=input2[28]
+ Y=sub_6_75_Y_add_6_39_n_8
Xsub_6_75_Y_add_6_39_g2__6783 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_34 B=sub_6_75_Y_add_6_39_n_78 Y=out[31]
Xsub_6_75_Y_add_6_39_g942__3680 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_32 B=sub_6_75_Y_add_6_39_n_75 Y=out[29]
Xsub_6_75_Y_add_6_39_g943__1617 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_50 B=sub_6_75_Y_add_6_39_n_72 Y=out[27]
Xsub_6_75_Y_add_6_39_g944__2802 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_54 B=sub_6_75_Y_add_6_39_n_69 Y=out[25]
Xsub_6_75_Y_add_6_39_g945__1705 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_52 B=sub_6_75_Y_add_6_39_n_66 Y=out[23]
Xsub_6_75_Y_add_6_39_g946__5122 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_56 B=sub_6_75_Y_add_6_39_n_63 Y=out[21]
Xsub_6_75_Y_add_6_39_g947__8246 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_48 B=sub_6_75_Y_add_6_39_n_60 Y=out[19]
.ENDS

.SUBCKT adder_1 input1[39] input1[38] input1[37] input1[36] input1[35]
+ input1[34] input1[33] input1[32] input1[31] input1[30] input1[29] input1[28]
+ input1[27] input1[26] input1[25] input1[24] input1[23] input1[22] input1[21]
+ input1[20] input1[19] input1[18] input1[17] input1[16] input1[15] input1[14]
+ input1[13] input1[12] input1[11] input1[10] input1[9] input1[8] input1[7]
+ input1[6] input1[5] input1[4] input1[3] input1[2] input1[1] input1[0]
+ input2[39] input2[38] input2[37] input2[36] input2[35] input2[34] input2[33]
+ input2[32] input2[31] input2[30] input2[29] input2[28] input2[27] input2[26]
+ input2[25] input2[24] input2[23] input2[22] input2[21] input2[20] input2[19]
+ input2[18] input2[17] input2[16] input2[15] input2[14] input2[13] input2[12]
+ input2[11] input2[10] input2[9] input2[8] input2[7] input2[6] input2[5]
+ input2[4] input2[3] input2[2] input2[1] input2[0] op out[39] out[38] out[37]
+ out[36] out[35] out[34] out[33] out[32] out[31] out[30] out[29] out[28]
+ out[27] out[26] out[25] out[24] out[23] out[22] out[21] out[20] out[19]
+ out[18] out[17] out[16] out[15] out[14] out[13] out[12] out[11] out[10]
+ out[9] out[8] out[7] out[6] out[5] out[4] out[3] out[2] out[1] out[0]
*.CONNECT out[0] VSS
*.CONNECT out[1] VSS
*.CONNECT out[2] VSS
*.CONNECT out[3] VSS
*.CONNECT out[4] VSS
*.CONNECT out[5] VSS
*.CONNECT out[6] VSS
*.CONNECT out[7] VSS
*.CONNECT out[8] VSS
*.CONNECT out[9] VSS
*.CONNECT out[10] VSS
*.CONNECT out[11] VSS
*.CONNECT out[12] VSS
*.CONNECT out[13] VSS
*.CONNECT out[14] VSS
*.CONNECT out[15] VSS
Xsub_6_75_Y_add_6_39_g827__7098 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_40 B=sub_6_75_Y_add_6_39_n_100 Y=out[39]
Xsub_6_75_Y_add_6_39_g828__6131 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_42 B=sub_6_75_Y_add_6_39_n_97 Y=out[38]
Xsub_6_75_Y_add_6_39_g829__1881 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_98 B=sub_6_75_Y_add_6_39_n_15 C=input2[38]
+ Y=sub_6_75_Y_add_6_39_n_100
Xsub_6_75_Y_add_6_39_g830__5115 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_41 B=sub_6_75_Y_add_6_39_n_94 Y=out[37]
Xsub_6_75_Y_add_6_39_g831 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_97
+ Y=sub_6_75_Y_add_6_39_n_98
Xsub_6_75_Y_add_6_39_g832__7482 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_95 B=sub_6_75_Y_add_6_39_n_15 C=input2[37]
+ Y=sub_6_75_Y_add_6_39_n_97
Xsub_6_75_Y_add_6_39_g833__4733 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_39 B=sub_6_75_Y_add_6_39_n_91 Y=out[36]
Xsub_6_75_Y_add_6_39_g834 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_94
+ Y=sub_6_75_Y_add_6_39_n_95
Xsub_6_75_Y_add_6_39_g835__6161 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_92 B=sub_6_75_Y_add_6_39_n_15 C=input2[36]
+ Y=sub_6_75_Y_add_6_39_n_94
Xsub_6_75_Y_add_6_39_g836__9315 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_38 B=sub_6_75_Y_add_6_39_n_88 Y=out[35]
Xsub_6_75_Y_add_6_39_g837 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_91
+ Y=sub_6_75_Y_add_6_39_n_92
Xsub_6_75_Y_add_6_39_g838__9945 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_89 B=sub_6_75_Y_add_6_39_n_15 C=input2[35]
+ Y=sub_6_75_Y_add_6_39_n_91
Xsub_6_75_Y_add_6_39_g839__2883 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_37 B=sub_6_75_Y_add_6_39_n_85 Y=out[34]
Xsub_6_75_Y_add_6_39_g840 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_88
+ Y=sub_6_75_Y_add_6_39_n_89
Xsub_6_75_Y_add_6_39_g841__2346 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_86 B=sub_6_75_Y_add_6_39_n_15 C=input2[34]
+ Y=sub_6_75_Y_add_6_39_n_88
Xsub_6_75_Y_add_6_39_g842__1666 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_36 B=sub_6_75_Y_add_6_39_n_82 Y=out[33]
Xsub_6_75_Y_add_6_39_g843 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_85
+ Y=sub_6_75_Y_add_6_39_n_86
Xsub_6_75_Y_add_6_39_g844__7410 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_83 B=sub_6_75_Y_add_6_39_n_15 C=input2[33]
+ Y=sub_6_75_Y_add_6_39_n_85
Xsub_6_75_Y_add_6_39_g845__6417 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_35 B=sub_6_75_Y_add_6_39_n_80 Y=out[32]
Xsub_6_75_Y_add_6_39_g846 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_82
+ Y=sub_6_75_Y_add_6_39_n_83
Xsub_6_75_Y_add_6_39_g847__5477 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_81 B=sub_6_75_Y_add_6_39_n_15 C=input2[32]
+ Y=sub_6_75_Y_add_6_39_n_82
Xsub_6_75_Y_add_6_39_g849 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_80
+ Y=sub_6_75_Y_add_6_39_n_81
Xsub_6_75_Y_add_6_39_g850__2398 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_78 B=sub_6_75_Y_add_6_39_n_15 C=input2[31]
+ Y=sub_6_75_Y_add_6_39_n_80
Xsub_6_75_Y_add_6_39_g851__5107 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_33 B=sub_6_75_Y_add_6_39_n_77 Y=out[30]
Xsub_6_75_Y_add_6_39_g853__6260 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_77 B=sub_6_75_Y_add_6_39_n_23
+ C=sub_6_75_Y_add_6_39_n_10 Y=sub_6_75_Y_add_6_39_n_78
Xsub_6_75_Y_add_6_39_g855__4319 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_75 B=sub_6_75_Y_add_6_39_n_29 C=input2[29]
+ Y=sub_6_75_Y_add_6_39_n_77
Xsub_6_75_Y_add_6_39_g856__8428 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_31 B=sub_6_75_Y_add_6_39_n_74 Y=out[28]
Xsub_6_75_Y_add_6_39_g858__5526 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_74 B=sub_6_75_Y_add_6_39_n_27 C=sub_6_75_Y_add_6_39_n_8
+ Y=sub_6_75_Y_add_6_39_n_75
Xsub_6_75_Y_add_6_39_g860__6783 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_72 B=sub_6_75_Y_add_6_39_n_24 C=input2[27]
+ Y=sub_6_75_Y_add_6_39_n_74
Xsub_6_75_Y_add_6_39_g861__3680 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_55 B=sub_6_75_Y_add_6_39_n_71 Y=out[26]
Xsub_6_75_Y_add_6_39_g863__1617 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_71 B=sub_6_75_Y_add_6_39_n_21
+ C=sub_6_75_Y_add_6_39_n_13 Y=sub_6_75_Y_add_6_39_n_72
Xsub_6_75_Y_add_6_39_g865__2802 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_69 B=sub_6_75_Y_add_6_39_n_17 C=input2[25]
+ Y=sub_6_75_Y_add_6_39_n_71
Xsub_6_75_Y_add_6_39_g866__1705 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_53 B=sub_6_75_Y_add_6_39_n_68 Y=out[24]
Xsub_6_75_Y_add_6_39_g868__5122 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_68 B=sub_6_75_Y_add_6_39_n_18 C=sub_6_75_Y_add_6_39_n_9
+ Y=sub_6_75_Y_add_6_39_n_69
Xsub_6_75_Y_add_6_39_g870__8246 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_66 B=sub_6_75_Y_add_6_39_n_26 C=input2[23]
+ Y=sub_6_75_Y_add_6_39_n_68
Xsub_6_75_Y_add_6_39_g871__7098 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_51 B=sub_6_75_Y_add_6_39_n_65 Y=out[22]
Xsub_6_75_Y_add_6_39_g873__6131 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_65 B=sub_6_75_Y_add_6_39_n_16
+ C=sub_6_75_Y_add_6_39_n_14 Y=sub_6_75_Y_add_6_39_n_66
Xsub_6_75_Y_add_6_39_g875__1881 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_63 B=sub_6_75_Y_add_6_39_n_30 C=input2[21]
+ Y=sub_6_75_Y_add_6_39_n_65
Xsub_6_75_Y_add_6_39_g876__5115 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_49 B=sub_6_75_Y_add_6_39_n_62 Y=out[20]
Xsub_6_75_Y_add_6_39_g878__7482 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_12 B=sub_6_75_Y_add_6_39_n_25
+ C=sub_6_75_Y_add_6_39_n_62 Y=sub_6_75_Y_add_6_39_n_63
Xsub_6_75_Y_add_6_39_g880__4733 MAJIxp5_ASAP7_75t_SL $PINS A=input2[19]
+ B=sub_6_75_Y_add_6_39_n_20 C=sub_6_75_Y_add_6_39_n_60
+ Y=sub_6_75_Y_add_6_39_n_62
Xsub_6_75_Y_add_6_39_g881__6161 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_47 B=sub_6_75_Y_add_6_39_n_57 Y=out[18]
Xsub_6_75_Y_add_6_39_g883__9315 MAJIxp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_11 B=sub_6_75_Y_add_6_39_n_19
+ C=sub_6_75_Y_add_6_39_n_57 Y=sub_6_75_Y_add_6_39_n_60
Xsub_6_75_Y_add_6_39_g884__9945 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_43 B=sub_6_75_Y_add_6_39_n_46 Y=out[17]
Xsub_6_75_Y_add_6_39_g885__2883 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_45 B=op Y=out[16]
Xsub_6_75_Y_add_6_39_g886__2346 MAJIxp5_ASAP7_75t_SL $PINS A=input2[17]
+ B=sub_6_75_Y_add_6_39_n_28 C=sub_6_75_Y_add_6_39_n_44
+ Y=sub_6_75_Y_add_6_39_n_57
Xsub_6_75_Y_add_6_39_g887__1666 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_30 B=input2[21] Y=sub_6_75_Y_add_6_39_n_56
Xsub_6_75_Y_add_6_39_g888__7410 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_21 B=sub_6_75_Y_add_6_39_n_13
+ Y=sub_6_75_Y_add_6_39_n_55
Xsub_6_75_Y_add_6_39_g889__6417 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_17 B=input2[25] Y=sub_6_75_Y_add_6_39_n_54
Xsub_6_75_Y_add_6_39_g890__5477 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_18 B=input2[24] Y=sub_6_75_Y_add_6_39_n_53
Xsub_6_75_Y_add_6_39_g891__2398 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_26 B=input2[23] Y=sub_6_75_Y_add_6_39_n_52
Xsub_6_75_Y_add_6_39_g892__5107 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_16 B=sub_6_75_Y_add_6_39_n_14
+ Y=sub_6_75_Y_add_6_39_n_51
Xsub_6_75_Y_add_6_39_g893__6260 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_24 B=input2[27] Y=sub_6_75_Y_add_6_39_n_50
Xsub_6_75_Y_add_6_39_g894__4319 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_25 B=sub_6_75_Y_add_6_39_n_12
+ Y=sub_6_75_Y_add_6_39_n_49
Xsub_6_75_Y_add_6_39_g895__8428 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_20 B=input2[19] Y=sub_6_75_Y_add_6_39_n_48
Xsub_6_75_Y_add_6_39_g896__5526 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_19 B=sub_6_75_Y_add_6_39_n_11
+ Y=sub_6_75_Y_add_6_39_n_47
Xsub_6_75_Y_add_6_39_g897__6783 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_28 B=input2[17] Y=sub_6_75_Y_add_6_39_n_46
Xsub_6_75_Y_add_6_39_g898__3680 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_22 B=input2[16] Y=sub_6_75_Y_add_6_39_n_45
Xsub_6_75_Y_add_6_39_g899 INVxp67_ASAP7_75t_SL $PINS A=sub_6_75_Y_add_6_39_n_43
+ Y=sub_6_75_Y_add_6_39_n_44
Xsub_6_75_Y_add_6_39_g900__1617 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[38] Y=sub_6_75_Y_add_6_39_n_42
Xsub_6_75_Y_add_6_39_g901__2802 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[37] Y=sub_6_75_Y_add_6_39_n_41
Xsub_6_75_Y_add_6_39_g902__1705 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[39] Y=sub_6_75_Y_add_6_39_n_40
Xsub_6_75_Y_add_6_39_g903__5122 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[36] Y=sub_6_75_Y_add_6_39_n_39
Xsub_6_75_Y_add_6_39_g904__8246 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[35] Y=sub_6_75_Y_add_6_39_n_38
Xsub_6_75_Y_add_6_39_g905__7098 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[34] Y=sub_6_75_Y_add_6_39_n_37
Xsub_6_75_Y_add_6_39_g906__6131 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[33] Y=sub_6_75_Y_add_6_39_n_36
Xsub_6_75_Y_add_6_39_g907__1881 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[32] Y=sub_6_75_Y_add_6_39_n_35
Xsub_6_75_Y_add_6_39_g908__5115 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_15 B=input2[31] Y=sub_6_75_Y_add_6_39_n_34
Xsub_6_75_Y_add_6_39_g909__7482 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_23 B=sub_6_75_Y_add_6_39_n_10
+ Y=sub_6_75_Y_add_6_39_n_33
Xsub_6_75_Y_add_6_39_g910__4733 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_29 B=input2[29] Y=sub_6_75_Y_add_6_39_n_32
Xsub_6_75_Y_add_6_39_g911__6161 XNOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_27 B=input2[28] Y=sub_6_75_Y_add_6_39_n_31
Xsub_6_75_Y_add_6_39_g912__9315 MAJIxp5_ASAP7_75t_SL $PINS A=op
+ B=sub_6_75_Y_add_6_39_n_22 C=input2[16] Y=sub_6_75_Y_add_6_39_n_43
Xsub_6_75_Y_add_6_39_g913__9945 XOR2xp5_ASAP7_75t_SL $PINS A=input1[21] B=op
+ Y=sub_6_75_Y_add_6_39_n_30
Xsub_6_75_Y_add_6_39_g914__2883 XOR2xp5_ASAP7_75t_SL $PINS A=input1[29] B=op
+ Y=sub_6_75_Y_add_6_39_n_29
Xsub_6_75_Y_add_6_39_g915__2346 XOR2xp5_ASAP7_75t_SL $PINS A=input1[17] B=op
+ Y=sub_6_75_Y_add_6_39_n_28
Xsub_6_75_Y_add_6_39_g916__1666 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[28] B=op
+ Y=sub_6_75_Y_add_6_39_n_27
Xsub_6_75_Y_add_6_39_g917__7410 XOR2xp5_ASAP7_75t_SL $PINS A=input1[23] B=op
+ Y=sub_6_75_Y_add_6_39_n_26
Xsub_6_75_Y_add_6_39_g918__6417 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[20] B=op
+ Y=sub_6_75_Y_add_6_39_n_25
Xsub_6_75_Y_add_6_39_g919__5477 XOR2xp5_ASAP7_75t_SL $PINS A=input1[27] B=op
+ Y=sub_6_75_Y_add_6_39_n_24
Xsub_6_75_Y_add_6_39_g920__2398 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[30] B=op
+ Y=sub_6_75_Y_add_6_39_n_23
Xsub_6_75_Y_add_6_39_g921__5107 XOR2xp5_ASAP7_75t_SL $PINS A=input1[16] B=op
+ Y=sub_6_75_Y_add_6_39_n_22
Xsub_6_75_Y_add_6_39_g922__6260 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[26] B=op
+ Y=sub_6_75_Y_add_6_39_n_21
Xsub_6_75_Y_add_6_39_g923__4319 XOR2xp5_ASAP7_75t_SL $PINS A=input1[19] B=op
+ Y=sub_6_75_Y_add_6_39_n_20
Xsub_6_75_Y_add_6_39_g924__8428 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[18] B=op
+ Y=sub_6_75_Y_add_6_39_n_19
Xsub_6_75_Y_add_6_39_g925__5526 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[24] B=op
+ Y=sub_6_75_Y_add_6_39_n_18
Xsub_6_75_Y_add_6_39_g926__6783 XOR2xp5_ASAP7_75t_SL $PINS A=input1[25] B=op
+ Y=sub_6_75_Y_add_6_39_n_17
Xsub_6_75_Y_add_6_39_g927__3680 XNOR2xp5_ASAP7_75t_SL $PINS A=input1[22] B=op
+ Y=sub_6_75_Y_add_6_39_n_16
Xsub_6_75_Y_add_6_39_g928__1617 XOR2x1_ASAP7_75t_SL $PINS A=input1[31] B=op
+ Y=sub_6_75_Y_add_6_39_n_15
Xsub_6_75_Y_add_6_39_g929 INVx1_ASAP7_75t_SL $PINS A=input2[22]
+ Y=sub_6_75_Y_add_6_39_n_14
Xsub_6_75_Y_add_6_39_g930 INVx1_ASAP7_75t_SL $PINS A=input2[26]
+ Y=sub_6_75_Y_add_6_39_n_13
Xsub_6_75_Y_add_6_39_g931 INVx1_ASAP7_75t_SL $PINS A=input2[20]
+ Y=sub_6_75_Y_add_6_39_n_12
Xsub_6_75_Y_add_6_39_g932 INVx1_ASAP7_75t_SL $PINS A=input2[18]
+ Y=sub_6_75_Y_add_6_39_n_11
Xsub_6_75_Y_add_6_39_g933 INVx1_ASAP7_75t_SL $PINS A=input2[30]
+ Y=sub_6_75_Y_add_6_39_n_10
Xsub_6_75_Y_add_6_39_g934 INVx1_ASAP7_75t_SL $PINS A=input2[24]
+ Y=sub_6_75_Y_add_6_39_n_9
Xsub_6_75_Y_add_6_39_g935 INVx1_ASAP7_75t_SL $PINS A=input2[28]
+ Y=sub_6_75_Y_add_6_39_n_8
Xsub_6_75_Y_add_6_39_g2__2802 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_34 B=sub_6_75_Y_add_6_39_n_78 Y=out[31]
Xsub_6_75_Y_add_6_39_g942__1705 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_32 B=sub_6_75_Y_add_6_39_n_75 Y=out[29]
Xsub_6_75_Y_add_6_39_g943__5122 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_50 B=sub_6_75_Y_add_6_39_n_72 Y=out[27]
Xsub_6_75_Y_add_6_39_g944__8246 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_54 B=sub_6_75_Y_add_6_39_n_69 Y=out[25]
Xsub_6_75_Y_add_6_39_g945__7098 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_52 B=sub_6_75_Y_add_6_39_n_66 Y=out[23]
Xsub_6_75_Y_add_6_39_g946__6131 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_56 B=sub_6_75_Y_add_6_39_n_63 Y=out[21]
Xsub_6_75_Y_add_6_39_g947__1881 XOR2xp5_ASAP7_75t_SL $PINS
+ A=sub_6_75_Y_add_6_39_n_48 B=sub_6_75_Y_add_6_39_n_60 Y=out[19]
.ENDS

.SUBCKT alu_controller Sclk Clear en_FIR sleep_flag rjdataL[15] rjdataL[14]
+ rjdataL[13] rjdataL[12] rjdataL[11] rjdataL[10] rjdataL[9] rjdataL[8]
+ rjdataL[7] rjdataL[6] rjdataL[5] rjdataL[4] rjdataL[3] rjdataL[2] rjdataL[1]
+ rjdataL[0] coeffdataL[15] coeffdataL[14] coeffdataL[13] coeffdataL[12]
+ coeffdataL[11] coeffdataL[10] coeffdataL[9] coeffdataL[8] coeffdataL[7]
+ coeffdataL[6] coeffdataL[5] coeffdataL[4] coeffdataL[3] coeffdataL[2]
+ coeffdataL[1] coeffdataL[0] indataL[15] indataL[14] indataL[13] indataL[12]
+ indataL[11] indataL[10] indataL[9] indataL[8] indataL[7] indataL[6]
+ indataL[5] indataL[4] indataL[3] indataL[2] indataL[1] indataL[0] rjdataR[15]
+ rjdataR[14] rjdataR[13] rjdataR[12] rjdataR[11] rjdataR[10] rjdataR[9]
+ rjdataR[8] rjdataR[7] rjdataR[6] rjdataR[5] rjdataR[4] rjdataR[3] rjdataR[2]
+ rjdataR[1] rjdataR[0] coeffdataR[15] coeffdataR[14] coeffdataR[13]
+ coeffdataR[12] coeffdataR[11] coeffdataR[10] coeffdataR[9] coeffdataR[8]
+ coeffdataR[7] coeffdataR[6] coeffdataR[5] coeffdataR[4] coeffdataR[3]
+ coeffdataR[2] coeffdataR[1] coeffdataR[0] indataR[15] indataR[14] indataR[13]
+ indataR[12] indataR[11] indataR[10] indataR[9] indataR[8] indataR[7]
+ indataR[6] indataR[5] indataR[4] indataR[3] indataR[2] indataR[1] indataR[0]
+ addL_input[39] addL_input[38] addL_input[37] addL_input[36] addL_input[35]
+ addL_input[34] addL_input[33] addL_input[32] addL_input[31] addL_input[30]
+ addL_input[29] addL_input[28] addL_input[27] addL_input[26] addL_input[25]
+ addL_input[24] addL_input[23] addL_input[22] addL_input[21] addL_input[20]
+ addL_input[19] addL_input[18] addL_input[17] addL_input[16] addL_input[15]
+ addL_input[14] addL_input[13] addL_input[12] addL_input[11] addL_input[10]
+ addL_input[9] addL_input[8] addL_input[7] addL_input[6] addL_input[5]
+ addL_input[4] addL_input[3] addL_input[2] addL_input[1] addL_input[0]
+ addR_input[39] addR_input[38] addR_input[37] addR_input[36] addR_input[35]
+ addR_input[34] addR_input[33] addR_input[32] addR_input[31] addR_input[30]
+ addR_input[29] addR_input[28] addR_input[27] addR_input[26] addR_input[25]
+ addR_input[24] addR_input[23] addR_input[22] addR_input[21] addR_input[20]
+ addR_input[19] addR_input[18] addR_input[17] addR_input[16] addR_input[15]
+ addR_input[14] addR_input[13] addR_input[12] addR_input[11] addR_input[10]
+ addR_input[9] addR_input[8] addR_input[7] addR_input[6] addR_input[5]
+ addR_input[4] addR_input[3] addR_input[2] addR_input[1] addR_input[0]
+ rjL_enable coeffL_enable inputL_enable rjR_enable coeffR_enable inputR_enable
+ addsubL adderL_en shiftL_en loadL clearL enable_PISO_L addsubR adderR_en
+ shiftR_en loadR clearR enable_PISO_R rjL_addr[3] rjL_addr[2] rjL_addr[1]
+ rjL_addr[0] coeffL_addr[8] coeffL_addr[7] coeffL_addr[6] coeffL_addr[5]
+ coeffL_addr[4] coeffL_addr[3] coeffL_addr[2] coeffL_addr[1] coeffL_addr[0]
+ inputL_addr[7] inputL_addr[6] inputL_addr[5] inputL_addr[4] inputL_addr[3]
+ inputL_addr[2] inputL_addr[1] inputL_addr[0] rjR_addr[3] rjR_addr[2]
+ rjR_addr[1] rjR_addr[0] coeffR_addr[8] coeffR_addr[7] coeffR_addr[6]
+ coeffR_addr[5] coeffR_addr[4] coeffR_addr[3] coeffR_addr[2] coeffR_addr[1]
+ coeffR_addr[0] inputR_addr[7] inputR_addr[6] inputR_addr[5] inputR_addr[4]
+ inputR_addr[3] inputR_addr[2] inputR_addr[1] inputR_addr[0]
*.CONNECT adderR_en VSS
*.CONNECT adderL_en VSS
*.CONNECT coeffR_enable VSS
*.CONNECT coeffL_enable VSS
*.CONNECT addR_input[0] VSS
*.CONNECT addR_input[1] VSS
*.CONNECT addR_input[2] VSS
*.CONNECT addR_input[3] VSS
*.CONNECT addR_input[4] VSS
*.CONNECT addR_input[5] VSS
*.CONNECT addR_input[6] VSS
*.CONNECT addR_input[7] VSS
*.CONNECT addR_input[8] VSS
*.CONNECT addR_input[9] VSS
*.CONNECT addR_input[10] VSS
*.CONNECT addR_input[11] VSS
*.CONNECT addR_input[12] VSS
*.CONNECT addR_input[13] VSS
*.CONNECT addR_input[14] VSS
*.CONNECT addR_input[15] VSS
*.CONNECT addR_input[16] VSS
*.CONNECT addR_input[17] VSS
*.CONNECT addR_input[18] VSS
*.CONNECT addR_input[19] VSS
*.CONNECT addR_input[20] VSS
*.CONNECT addR_input[21] VSS
*.CONNECT addR_input[22] VSS
*.CONNECT addR_input[23] VSS
*.CONNECT addR_input[24] VSS
*.CONNECT addR_input[25] VSS
*.CONNECT addR_input[26] VSS
*.CONNECT addR_input[27] VSS
*.CONNECT addR_input[28] VSS
*.CONNECT addR_input[29] VSS
*.CONNECT addR_input[30] VSS
*.CONNECT addR_input[31] VSS
*.CONNECT addR_input[32] VSS
*.CONNECT addR_input[33] VSS
*.CONNECT addR_input[34] VSS
*.CONNECT addR_input[35] VSS
*.CONNECT addR_input[36] VSS
*.CONNECT addR_input[37] VSS
*.CONNECT addR_input[38] VSS
*.CONNECT addR_input[39] VSS
*.CONNECT addL_input[0] VSS
*.CONNECT addL_input[1] VSS
*.CONNECT addL_input[2] VSS
*.CONNECT addL_input[3] VSS
*.CONNECT addL_input[4] VSS
*.CONNECT addL_input[5] VSS
*.CONNECT addL_input[6] VSS
*.CONNECT addL_input[7] VSS
*.CONNECT addL_input[8] VSS
*.CONNECT addL_input[9] VSS
*.CONNECT addL_input[10] VSS
*.CONNECT addL_input[11] VSS
*.CONNECT addL_input[12] VSS
*.CONNECT addL_input[13] VSS
*.CONNECT addL_input[14] VSS
*.CONNECT addL_input[15] VSS
*.CONNECT addL_input[16] VSS
*.CONNECT addL_input[17] VSS
*.CONNECT addL_input[18] VSS
*.CONNECT addL_input[19] VSS
*.CONNECT addL_input[20] VSS
*.CONNECT addL_input[21] VSS
*.CONNECT addL_input[22] VSS
*.CONNECT addL_input[23] VSS
*.CONNECT addL_input[24] VSS
*.CONNECT addL_input[25] VSS
*.CONNECT addL_input[26] VSS
*.CONNECT addL_input[27] VSS
*.CONNECT addL_input[28] VSS
*.CONNECT addL_input[29] VSS
*.CONNECT addL_input[30] VSS
*.CONNECT addL_input[31] VSS
*.CONNECT addL_input[32] VSS
*.CONNECT addL_input[33] VSS
*.CONNECT addL_input[34] VSS
*.CONNECT addL_input[35] VSS
*.CONNECT addL_input[36] VSS
*.CONNECT addL_input[37] VSS
*.CONNECT addL_input[38] VSS
*.CONNECT addL_input[39] VSS
XclearL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_338 QN=clearL
XclearR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_337 QN=clearR
Xenable_PISO_L_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_339
+ QN=enable_PISO_L
Xenable_PISO_R_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_340
+ QN=enable_PISO_R
XinputL_enable_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_533
+ QN=inputL_enable
XinputR_enable_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_531
+ QN=inputR_enable
XloadL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_415 QN=loadL
XloadR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_414 QN=loadR
XshiftL_en_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_463 QN=shiftL_en
XshiftR_en_reg DFFLQNx1_ASAP7_75t_L $PINS CLK=Sclk D=n_462 QN=shiftR_en
Xg9137__5115 AND2x2_ASAP7_75t_SL $PINS A=n_463 B=n_533 Y=n_415
Xg9138__7482 AND2x2_ASAP7_75t_SL $PINS A=n_462 B=n_531 Y=n_414
Xg9139 INVx1_ASAP7_75t_SL $PINS A=n_413 Y=n_533
Xg9140__4733 AOI21xp5_ASAP7_75t_SL $PINS A1=n_411 A2=n_417 B=n_460 Y=n_413
Xg9141 INVx1_ASAP7_75t_SL $PINS A=n_412 Y=n_531
Xg9142__6161 AOI21xp5_ASAP7_75t_SL $PINS A1=n_410 A2=n_418 B=n_461 Y=n_412
Xg9143__9315 AOI21xp5_ASAP7_75t_SL $PINS A1=n_449 A2=n_444 B=memL_overflow
+ Y=n_411
Xg9144__9945 AOI21xp5_ASAP7_75t_SL $PINS A1=n_448 A2=n_443 B=memR_overflow
+ Y=n_410
Xg9145__2883 MAJIxp5_ASAP7_75t_SL $PINS A=n_408 B=coeffdataR[6] C=n_399 Y=n_448
Xg9146__2346 MAJIxp5_ASAP7_75t_SL $PINS A=n_409 B=coeffdataL[6] C=n_400 Y=n_449
Xg9147 INVxp67_ASAP7_75t_SL $PINS A=n_409 Y=n_450
Xg9148__1666 AOI21xp5_ASAP7_75t_SL $PINS A1=n_451 A2=n_435 B=n_402 Y=n_409
Xg9149 INVxp67_ASAP7_75t_SL $PINS A=n_408 Y=n_447
Xg9150__7410 AOI21xp5_ASAP7_75t_SL $PINS A1=n_446 A2=n_431 B=n_401 Y=n_408
Xg9153__6417 NAND2xp5_ASAP7_75t_SL $PINS A=n_338 B=n_537 Y=n_460
Xg9154__5477 NAND2xp5_ASAP7_75t_SL $PINS A=n_337 B=n_459 Y=n_461
Xg9155__2398 OR2x2_ASAP7_75t_SL $PINS A=n_483 B=n_537 Y=n_463
Xg9156__5107 MAJIxp5_ASAP7_75t_SL $PINS A=n_407 B=coeffdataL[4] C=n_383 Y=n_451
Xg9157__6260 MAJIxp5_ASAP7_75t_SL $PINS A=n_406 B=coeffdataR[4] C=n_384 Y=n_446
Xg9158__4319 OR2x2_ASAP7_75t_SL $PINS A=n_482 B=n_459 Y=n_462
Xg9159__8428 NAND3xp33_ASAP7_75t_SL $PINS A=n_403 B=n_373 C=n_359 Y=n_537
Xg9160__5526 NAND4xp25_ASAP7_75t_SL $PINS A=n_398 B=n_356 C=n_355 D=n_348
+ Y=n_459
Xg9161__6783 OR2x2_ASAP7_75t_SL $PINS A=coeffdataL[7] B=n_404 Y=n_417
Xg9162__3680 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[7] B=n_404 Y=n_444
Xg9163__1617 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[7] B=n_405 Y=n_443
Xg9164 INVxp67_ASAP7_75t_SL $PINS A=n_407 Y=n_455
Xg9165 INVxp67_ASAP7_75t_SL $PINS A=n_406 Y=n_454
Xg9166__2802 OR2x2_ASAP7_75t_SL $PINS A=coeffdataR[7] B=n_405 Y=n_418
Xg9167__1705 AOI21xp5_ASAP7_75t_SL $PINS A1=n_452 A2=n_436 B=n_392 Y=n_407
Xg9168__5122 AOI21xp5_ASAP7_75t_SL $PINS A1=n_453 A2=n_438 B=n_386 Y=n_406
Xg9169__8246 OR2x2_ASAP7_75t_SL $PINS A=coeffdataR[6] B=n_399 Y=n_420
Xg9170__7098 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[6] B=n_400 Y=n_432
Xg9171__6131 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[6] B=n_399 Y=n_442
Xg9172__1881 AOI221xp5_ASAP7_75t_SL $PINS A1=n_480 A2=rjdataL[6] B1=n_481
+ B2=rjdataL[7] C=n_397 Y=n_403
Xg9173__5115 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[7] B=n_396 Y=n_405
Xg9174__7482 OR2x2_ASAP7_75t_SL $PINS A=coeffdataL[6] B=n_400 Y=n_419
Xg9175__4733 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[7] B=n_395 Y=n_404
Xg9176 INVxp67_ASAP7_75t_SL $PINS A=n_402 Y=n_422
Xg9177 INVxp67_ASAP7_75t_SL $PINS A=n_401 Y=n_421
Xg9178__6161 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[5] B=n_393 Y=n_431
Xg9179__9315 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[5] B=n_394 Y=n_435
Xg9180__9945 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataL[5] B=n_394 Y=n_402
Xg9181__2883 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataR[5] B=n_393 Y=n_401
Xg9182__2346 MAJIxp5_ASAP7_75t_SL $PINS A=n_387 B=coeffdataL[2] C=n_372 Y=n_452
Xg9183__1666 NOR5xp2_ASAP7_75t_SL $PINS A=n_374 B=n_362 C=n_363 D=n_354 E=n_349
+ Y=n_398
Xg9184__7410 OAI211xp5_ASAP7_75t_SL $PINS A1=rjdataL[7] A2=n_481 B=n_382
+ C=n_358 Y=n_397
Xg9185__6417 AOI21xp5_ASAP7_75t_SL $PINS A1=n_389 A2=xcntL[6] B=n_395 Y=n_400
Xg9186__5477 AOI21xp5_ASAP7_75t_SL $PINS A1=n_391 A2=xcntR[6] B=n_396 Y=n_399
Xg9187__2398 MAJIxp5_ASAP7_75t_SL $PINS A=n_385 B=coeffdataR[2] C=n_369 Y=n_453
Xg9188__5107 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[4] B=n_383 Y=n_440
Xg9189__6260 OR2x2_ASAP7_75t_SL $PINS A=coeffdataL[4] B=n_383 Y=n_424
Xg9190__4319 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[6] B=n_391 Y=n_396
Xg9191__8428 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[6] B=n_389 Y=n_395
Xg9192__5526 AOI21xp5_ASAP7_75t_SL $PINS A1=n_381 A2=xcntL[5] B=n_388 Y=n_394
Xg9193__6783 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[4] B=n_384 Y=n_441
Xg9194__3680 OR2x2_ASAP7_75t_SL $PINS A=coeffdataR[4] B=n_384 Y=n_423
Xg9195__1617 AOI21xp5_ASAP7_75t_SL $PINS A1=n_379 A2=xcntR[5] B=n_390 Y=n_393
Xg9196 INVxp67_ASAP7_75t_SL $PINS A=n_392 Y=n_426
Xg9197 INVxp67_ASAP7_75t_SL $PINS A=n_390 Y=n_391
Xg9198 INVxp67_ASAP7_75t_SL $PINS A=n_388 Y=n_389
Xg9199__2802 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataL[3] B=n_376 Y=n_392
Xg9200__1705 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[3] B=n_376 Y=n_436
Xg9201__5122 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[3] B=n_377 Y=n_438
Xg9202__8246 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[5] B=n_379 Y=n_390
Xg9203__7098 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[5] B=n_381 Y=n_388
Xg9204 INVxp67_ASAP7_75t_SL $PINS A=n_387 Y=n_456
Xg9205 INVxp67_ASAP7_75t_SL $PINS A=n_386 Y=n_425
Xg9206 INVxp67_ASAP7_75t_SL $PINS A=n_385 Y=n_445
Xg9207__6131 AOI221xp5_ASAP7_75t_SL $PINS A1=n_476 A2=rjdataL[2] B1=n_477
+ B2=rjdataL[3] C=n_375 Y=n_382
Xg9208__1881 AOI21xp5_ASAP7_75t_SL $PINS A1=n_439 A2=n_457 B=n_370 Y=n_387
Xg9209__5115 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataR[3] B=n_377 Y=n_386
Xg9210__7482 AOI21xp5_ASAP7_75t_SL $PINS A1=n_434 A2=n_458 B=n_371 Y=n_385
Xg9211__4733 AOI21xp5_ASAP7_75t_SL $PINS A1=n_368 A2=xcntR[4] B=n_378 Y=n_384
Xg9212__6161 AOI21xp5_ASAP7_75t_SL $PINS A1=n_366 A2=xcntL[4] B=n_380 Y=n_383
Xg9213 INVx1_ASAP7_75t_SL $PINS A=n_380 Y=n_381
Xg9214 INVx1_ASAP7_75t_SL $PINS A=n_378 Y=n_379
Xg9215__9315 OR2x2_ASAP7_75t_SL $PINS A=coeffdataL[2] B=n_372 Y=n_428
Xg9216__9945 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[2] B=n_369 Y=n_433
Xg9217__2883 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[2] B=n_372 Y=n_437
Xg9218__2346 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[4] B=n_366 Y=n_380
Xg9219__1666 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[4] B=n_368 Y=n_378
Xg9220__7410 OAI211xp5_ASAP7_75t_SL $PINS A1=rjdataL[2] A2=n_476 B=n_357
+ C=n_347 Y=n_375
Xg9221__6417 NAND2xp5_ASAP7_75t_SL $PINS A=n_360 B=n_361 Y=n_374
Xg9222__5477 AOI21xp5_ASAP7_75t_SL $PINS A1=n_479 A2=rjdataL[5] B=n_364 Y=n_373
Xg9223__2398 AOI21xp5_ASAP7_75t_SL $PINS A1=n_351 A2=xcntR[3] B=n_367 Y=n_377
Xg9224__5107 AOI21xp5_ASAP7_75t_SL $PINS A1=n_353 A2=xcntL[3] B=n_365 Y=n_376
Xg9225__6260 OR2x2_ASAP7_75t_SL $PINS A=coeffdataR[2] B=n_369 Y=n_427
Xg9226 INVxp67_ASAP7_75t_SL $PINS A=n_371 Y=n_430
Xg9227 INVxp67_ASAP7_75t_SL $PINS A=n_370 Y=n_429
Xg9228 INVx1_ASAP7_75t_SL $PINS A=n_367 Y=n_368
Xg9229 INVx1_ASAP7_75t_SL $PINS A=n_365 Y=n_366
Xg9230__4319 OAI22xp5_ASAP7_75t_SL $PINS A1=rjdataL[5] A2=n_479 B1=rjdataL[6]
+ B2=n_480 Y=n_364
Xg9231__8428 AOI21xp5_ASAP7_75t_SL $PINS A1=n_344 A2=xcntL[2] B=n_352 Y=n_372
Xg9232__5526 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[1] B=n_465 Y=n_439
Xg9233__6783 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[1] B=n_464 Y=n_434
Xg9234__3680 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataR[1] B=n_464 Y=n_371
Xg9235__1617 NOR2xp33_ASAP7_75t_SL $PINS A=coeffdataL[1] B=n_465 Y=n_370
Xg9236__2802 AOI21xp5_ASAP7_75t_SL $PINS A1=n_346 A2=xcntR[2] B=n_350 Y=n_369
Xg9237__1705 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[3] B=n_351 Y=n_367
Xg9238__5122 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[3] B=n_353 Y=n_365
Xg9239__8246 OAI22xp5_ASAP7_75t_SL $PINS A1=rjdataR[2] A2=n_468 B1=rjdataR[3]
+ B2=n_469 Y=n_363
Xg9240__7098 OAI22xp5_ASAP7_75t_SL $PINS A1=rjdataR[0] A2=n_466 B1=rjdataR[1]
+ B2=n_467 Y=n_362
Xg9241__6131 AOI22xp5_ASAP7_75t_SL $PINS A1=rjdataR[0] A2=n_466 B1=rjdataR[1]
+ B2=n_467 Y=n_361
Xg9242__1881 AOI22xp5_ASAP7_75t_SL $PINS A1=rjdataR[2] A2=n_468 B1=rjdataR[3]
+ B2=n_469 Y=n_360
Xg9243__5115 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[4] B=n_478 Y=n_359
Xg9244__7482 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[0] B=n_474 Y=n_358
Xg9245__4733 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[1] B=n_475 Y=n_357
Xg9246__6161 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[6] B=n_472 Y=n_356
Xg9247__9315 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[5] B=n_471 Y=n_355
Xg9248__9945 XNOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[7] B=n_473 Y=n_354
Xg9249 INVx1_ASAP7_75t_SL $PINS A=n_352 Y=n_353
Xg9250 INVx1_ASAP7_75t_SL $PINS A=n_350 Y=n_351
Xg9253__2883 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[2] B=n_344 Y=n_352
Xg9254__2346 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[2] B=n_346 Y=n_350
Xg9255__1666 NOR2xp33_ASAP7_75t_SL $PINS A=rjdataR[4] B=n_470 Y=n_349
Xg9256__7410 NAND2xp5_ASAP7_75t_SL $PINS A=rjdataR[4] B=n_470 Y=n_348
Xg9257__6417 OR2x2_ASAP7_75t_SL $PINS A=rjdataL[3] B=n_477 Y=n_347
Xg9258__5477 AOI21xp5_ASAP7_75t_SL $PINS A1=xcntR[1] A2=xcntR[0] B=n_345
+ Y=n_464
Xg9259__2398 AOI21xp5_ASAP7_75t_SL $PINS A1=xcntL[1] A2=xcntL[0] B=n_343
+ Y=n_465
Xg9260 INVx1_ASAP7_75t_SL $PINS A=n_338 Y=n_483
Xg9261 INVx1_ASAP7_75t_SL $PINS A=n_337 Y=n_482
Xg9267__5107 NAND2xp5_ASAP7_75t_SL $PINS A=kL[4] B=n_339 Y=n_478
Xg9268__6260 NAND2xp5_ASAP7_75t_SL $PINS A=kL[5] B=n_339 Y=n_479
Xg9269__4319 NAND2xp5_ASAP7_75t_SL $PINS A=kL[6] B=n_339 Y=n_480
Xg9270__8428 NAND2xp5_ASAP7_75t_SL $PINS A=kL[7] B=n_339 Y=n_481
Xg9271__5526 NAND2xp5_ASAP7_75t_SL $PINS A=kL[0] B=n_339 Y=n_474
Xg9272__6783 NAND2xp5_ASAP7_75t_SL $PINS A=kL[3] B=n_339 Y=n_477
Xg9273__3680 NAND2xp5_ASAP7_75t_SL $PINS A=kL[2] B=n_339 Y=n_476
Xg9275 INVx1_ASAP7_75t_SL $PINS A=n_345 Y=n_346
Xg9276 INVx1_ASAP7_75t_SL $PINS A=n_343 Y=n_344
Xg9277__1617 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataL[0] B=xcntL[0] Y=n_457
Xg9278__2802 NAND2xp5_ASAP7_75t_SL $PINS A=coeffdataR[0] B=xcntR[0] Y=n_458
Xg9279__1705 NAND2xp5_ASAP7_75t_SL $PINS A=kR[5] B=n_340 Y=n_471
Xg9280__5122 NAND2xp5_ASAP7_75t_SL $PINS A=kR[4] B=n_340 Y=n_470
Xg9281__8246 NAND2xp5_ASAP7_75t_SL $PINS A=kR[3] B=n_340 Y=n_469
Xg9282__7098 NAND2xp5_ASAP7_75t_SL $PINS A=kR[7] B=n_340 Y=n_473
Xg9283__6131 NAND2xp5_ASAP7_75t_SL $PINS A=kR[2] B=n_340 Y=n_468
Xg9284__1881 NAND2xp5_ASAP7_75t_SL $PINS A=kR[1] B=n_340 Y=n_467
Xg9285__5115 NAND2xp5_ASAP7_75t_SL $PINS A=kR[0] B=n_340 Y=n_466
Xg9286__7482 NOR2xp33_ASAP7_75t_SL $PINS A=xcntR[0] B=xcntR[1] Y=n_345
Xg9287__4733 NOR2xp33_ASAP7_75t_SL $PINS A=xcntL[0] B=xcntL[1] Y=n_343
Xg9288__6161 NAND2xp5_ASAP7_75t_SL $PINS A=kL[1] B=n_339 Y=n_475
Xg9289__9315 NAND2xp5_ASAP7_75t_SL $PINS A=kR[6] B=n_340 Y=n_472
Xg9290 INVx1_ASAP7_75t_SL $PINS A=work_statusR Y=n_342
Xg9291 INVx1_ASAP7_75t_SL $PINS A=work_statusL Y=n_341
Xg9292 INVx1_ASAP7_75t_SL $PINS A=outR Y=n_340
Xg9293 INVx1_ASAP7_75t_SL $PINS A=outL Y=n_339
Xg9294__9945 NOR2xp33_ASAP7_75t_SL $PINS A=start_workL B=n_341 Y=n_338
Xg9295__2883 NOR2xp33_ASAP7_75t_SL $PINS A=start_workR B=n_342 Y=n_337
XaddsubL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_125 QN=addsubL
XaddsubR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_99 QN=addsubR
XcoeffL_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_317
+ QN=coeffL_addr[0]
XcoeffL_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_318
+ QN=coeffL_addr[1]
XcoeffL_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_316
+ QN=coeffL_addr[2]
XcoeffL_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_315
+ QN=coeffL_addr[3]
XcoeffL_addr_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_314
+ QN=coeffL_addr[4]
XcoeffL_addr_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_321
+ QN=coeffL_addr[5]
XcoeffL_addr_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_328
+ QN=coeffL_addr[6]
XcoeffL_addr_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_327
+ QN=coeffL_addr[7]
XcoeffL_addr_reg[8] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_322
+ QN=coeffL_addr[8]
XcoeffL_enable_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_118 QN=rjL_enable
XcoeffR_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_326
+ QN=coeffR_addr[0]
XcoeffR_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_325
+ QN=coeffR_addr[1]
XcoeffR_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_324
+ QN=coeffR_addr[2]
XcoeffR_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_323
+ QN=coeffR_addr[3]
XcoeffR_addr_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_330
+ QN=coeffR_addr[4]
XcoeffR_addr_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_313
+ QN=coeffR_addr[5]
XcoeffR_addr_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_320
+ QN=coeffR_addr[6]
XcoeffR_addr_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_319
+ QN=coeffR_addr[7]
XcoeffR_addr_reg[8] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_329
+ QN=coeffR_addr[8]
XcoeffR_enable_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_117 QN=rjR_enable
XinputL_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_198
+ QN=inputL_addr[0]
XinputL_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_231
+ QN=inputL_addr[1]
XinputL_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_230
+ QN=inputL_addr[2]
XinputL_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_229
+ QN=inputL_addr[3]
XinputL_addr_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_228
+ QN=inputL_addr[4]
XinputL_addr_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_227
+ QN=inputL_addr[5]
XinputL_addr_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_212
+ QN=inputL_addr[6]
XinputL_addr_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_226
+ QN=inputL_addr[7]
XinputR_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_197
+ QN=inputR_addr[0]
XinputR_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_225
+ QN=inputR_addr[1]
XinputR_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_224
+ QN=inputR_addr[2]
XinputR_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_223
+ QN=inputR_addr[3]
XinputR_addr_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_222
+ QN=inputR_addr[4]
XinputR_addr_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_221
+ QN=inputR_addr[5]
XinputR_addr_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_220
+ QN=inputR_addr[6]
XinputR_addr_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_219
+ QN=inputR_addr[7]
XkL_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_67 QN=kL[0]
XkL_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_170 QN=kL[1]
XkL_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_202 QN=kL[2]
XkL_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_235 QN=kL[3]
XkL_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_258 QN=kL[4]
XkL_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_278 QN=kL[5]
XkL_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_292 QN=kL[6]
XkL_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_295 QN=kL[7]
XkR_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_68 QN=kR[0]
XkR_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_169 QN=kR[1]
XkR_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_203 QN=kR[2]
XkR_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_234 QN=kR[3]
XkR_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_257 QN=kR[4]
XkR_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_279 QN=kR[5]
XkR_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_287 QN=kR[6]
XkR_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_300 QN=kR[7]
XmemL_overflow_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_297
+ QN=memL_overflow
XmemR_overflow_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_306
+ QN=memR_overflow
Xnext_stateL_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_237
+ QN=next_stateL[0]
Xnext_stateL_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_201
+ QN=next_stateL[1]
Xnext_stateR_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_120
+ QN=next_stateR[0]
XoutL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_241 QN=outL
XoutR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_233 QN=outR
XrjL_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_166 QN=rjL_addr[0]
XrjL_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_238 QN=rjL_addr[1]
XrjL_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_254 QN=rjL_addr[2]
XrjL_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_276 QN=rjL_addr[3]
XrjR_addr_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_167 QN=rjR_addr[0]
XrjR_addr_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_239 QN=rjR_addr[1]
XrjR_addr_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_253 QN=rjR_addr[2]
XrjR_addr_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_275 QN=rjR_addr[3]
Xstart_workL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_236 QN=start_workL
Xstart_workR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_122 QN=start_workR
Xwork_statusL_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_336 QN=work_statusL
Xwork_statusR_reg DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_335 QN=work_statusR
XxcntL_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_272 QN=xcntL[0]
XxcntL_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_259 QN=xcntL[1]
XxcntL_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_252 QN=xcntL[2]
XxcntL_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_251 QN=xcntL[3]
XxcntL_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_274 QN=xcntL[4]
XxcntL_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_289 QN=xcntL[5]
XxcntL_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_299 QN=xcntL[6]
XxcntL_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_305 QN=xcntL[7]
XxcntR_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_196 QN=xcntR[0]
XxcntR_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_195 QN=xcntR[1]
XxcntR_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_218 QN=xcntR[2]
XxcntR_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_250 QN=xcntR[3]
XxcntR_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_273 QN=xcntR[4]
XxcntR_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_288 QN=xcntR[5]
XxcntR_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_298 QN=xcntR[6]
XxcntR_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_304 QN=xcntR[7]
Xg10518__2346 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_182 A2=n_334 B=work_statusL
+ C=n_171 Y=n_336
Xg10519__1666 AOI21xp5_ASAP7_75t_SL $PINS A1=n_333 A2=work_statusR B=n_69
+ Y=n_335
Xg10520__7410 AOI31xp33_ASAP7_75t_SL $PINS A1=n_332 A2=coeffL_addr[8]
+ A3=coeffL_addr[5] B=next_stateL[1] Y=n_334
Xg10521__6417 NAND5xp2_ASAP7_75t_SL $PINS A=n_331 B=coeffR_addr[1]
+ C=coeffR_addr[2] D=coeffR_addr[5] E=coeffR_addr[8] Y=n_333
Xg10522__5477 AND5x1_ASAP7_75t_SL $PINS A=n_312 B=rjL_addr[3] C=coeffL_addr[0]
+ D=coeffL_addr[1] E=coeffL_addr[2] Y=n_332
Xg10523__2398 AND5x1_ASAP7_75t_SL $PINS A=n_309 B=n_90 C=rjR_addr[2]
+ D=rjR_addr[3] E=coeffR_addr[0] Y=n_331
Xg10542__5107 AOI22xp5_ASAP7_75t_SL $PINS A1=n_3 A2=n_308 B1=coeffR_addr[4]
+ B2=n_310 Y=n_330
Xg10543__6260 AOI22xp5_ASAP7_75t_SL $PINS A1=n_303 A2=n_308 B1=coeffR_addr[8]
+ B2=n_310 Y=n_329
Xg10544__4319 AOI22xp5_ASAP7_75t_SL $PINS A1=n_8 A2=n_307 B1=coeffL_addr[6]
+ B2=n_311 Y=n_328
Xg10545__8428 AOI22xp5_ASAP7_75t_SL $PINS A1=n_296 A2=n_307 B1=coeffL_addr[7]
+ B2=n_311 Y=n_327
Xg10546__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffR_addr[0] A2=n_310 B1=n_74
+ B2=n_308 Y=n_326
Xg10547__6783 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffR_addr[1] A2=n_310 B1=n_147
+ B2=n_308 Y=n_325
Xg10548__3680 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffR_addr[2] A2=n_310 B1=n_189
+ B2=n_308 Y=n_324
Xg10549__1617 AOI22xp5_ASAP7_75t_SL $PINS A1=n_216 A2=n_308 B1=coeffR_addr[3]
+ B2=n_310 Y=n_323
Xg10550__2802 AOI22xp5_ASAP7_75t_SL $PINS A1=n_302 A2=n_307 B1=coeffL_addr[8]
+ B2=n_311 Y=n_322
Xg10551__1705 AOI22xp5_ASAP7_75t_SL $PINS A1=n_268 A2=n_307 B1=coeffL_addr[5]
+ B2=n_311 Y=n_321
Xg10552__5122 AOI22xp5_ASAP7_75t_SL $PINS A1=n_6 A2=n_308 B1=coeffR_addr[6]
+ B2=n_310 Y=n_320
Xg10553__8246 AOI22xp5_ASAP7_75t_SL $PINS A1=n_301 A2=n_308 B1=coeffR_addr[7]
+ B2=n_310 Y=n_319
Xg10554__7098 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffL_addr[1] A2=n_311 B1=n_144
+ B2=n_307 Y=n_318
Xg10555__6131 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffL_addr[0] A2=n_311 B1=n_71
+ B2=n_307 Y=n_317
Xg10556__1881 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffL_addr[2] A2=n_311 B1=n_186
+ B2=n_307 Y=n_316
Xg10557__5115 AOI22xp5_ASAP7_75t_SL $PINS A1=n_232 A2=n_307 B1=coeffL_addr[3]
+ B2=n_311 Y=n_315
Xg10558__7482 AOI22xp5_ASAP7_75t_SL $PINS A1=n_2 A2=n_307 B1=coeffL_addr[4]
+ B2=n_311 Y=n_314
Xg10559__4733 AOI22xp5_ASAP7_75t_SL $PINS A1=n_271 A2=n_308 B1=coeffR_addr[5]
+ B2=n_310 Y=n_313
Xg10560__6161 AND5x1_ASAP7_75t_SL $PINS A=n_290 B=coeffL_addr[7] C=rjL_addr[0]
+ D=rjL_addr[1] E=rjL_addr[2] Y=n_312
Xg10564__9315 AND5x1_ASAP7_75t_SL $PINS A=n_277 B=coeffR_addr[6]
+ C=coeffR_addr[7] D=rjR_addr[0] E=rjR_addr[1] Y=n_309
Xg10565__9945 NOR3xp33_ASAP7_75t_SL $PINS A=n_307 B=n_255 C=n_483 Y=n_311
Xg10566__2883 NOR3xp33_ASAP7_75t_SL $PINS A=n_308 B=n_256 C=n_482 Y=n_310
Xg10572__2346 OAI21xp5_ASAP7_75t_SL $PINS A1=memR_overflow A2=n_291 B=n_90
+ Y=n_306
Xg10573__1666 AOI22xp5_ASAP7_75t_SL $PINS A1=n_200 A2=n_284 B1=xcntL[7]
+ B2=n_172 Y=n_305
Xg10574__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_7 B1=xcntR[7] B2=n_70
+ Y=n_304
Xg10575__6417 AOI21xp5_ASAP7_75t_SL $PINS A1=n_293 A2=n_66 B=n_461 Y=n_308
Xg10576__5477 AOI21xp5_ASAP7_75t_SL $PINS A1=n_294 A2=n_98 B=n_460 Y=n_307
Xg10577__2398 OR2x2_ASAP7_75t_SL $PINS A=n_66 B=n_293 Y=n_303
Xg10578__5107 OR2x2_ASAP7_75t_SL $PINS A=n_98 B=n_294 Y=n_302
Xg10583__6260 XNOR2xp5_ASAP7_75t_SL $PINS A=n_86 B=n_280 Y=n_301
Xg10584__4319 NAND2xp5_ASAP7_75t_SL $PINS A=n_14 B=n_285 Y=n_300
Xg10585__8428 AOI22xp5_ASAP7_75t_SL $PINS A1=n_200 A2=n_270 B1=xcntL[6]
+ B2=n_172 Y=n_299
Xg10586__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_269 B1=xcntR[6] B2=n_70
+ Y=n_298
Xg10587__6783 AOI33xp33_ASAP7_75t_SL $PINS A1=xcntL[7] A2=n_200 A3=n_265
+ B1=n_65 B2=memL_overflow B3=n_15 Y=n_297
Xg10588__3680 XNOR2xp5_ASAP7_75t_SL $PINS A=n_76 B=n_282 Y=n_296
Xg10589__1617 NAND2xp5_ASAP7_75t_SL $PINS A=n_13 B=n_286 Y=n_295
Xg10590__2802 NAND2xp5_ASAP7_75t_SL $PINS A=n_4 B=n_13 Y=n_292
Xg10591__1705 NOR2xp33_ASAP7_75t_SL $PINS A=n_76 B=n_283 Y=n_294
Xg10592__5122 NOR2xp33_ASAP7_75t_SL $PINS A=n_86 B=n_281 Y=n_293
Xg10601__8246 AND3x1_ASAP7_75t_SL $PINS A=n_266 B=xcntR[7] C=en_FIR Y=n_291
Xg10602__7098 AND5x1_ASAP7_75t_SL $PINS A=n_193 B=n_194 C=coeffL_addr[3]
+ D=coeffL_addr[4] E=coeffL_addr[6] Y=n_290
Xg10603__6131 AOI22xp5_ASAP7_75t_SL $PINS A1=n_200 A2=n_262 B1=xcntL[5]
+ B2=n_172 Y=n_289
Xg10604__1881 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_263 B1=xcntR[5] B2=n_70
+ Y=n_288
Xg10605__5115 NAND2xp5_ASAP7_75t_SL $PINS A=n_5 B=n_14 Y=n_287
Xg10606__7482 XNOR2xp5_ASAP7_75t_SL $PINS A=n_481 B=n_249 Y=n_286
Xg10607__4733 XNOR2xp5_ASAP7_75t_SL $PINS A=n_473 B=n_248 Y=n_285
Xg10610__6161 XOR2xp5_ASAP7_75t_SL $PINS A=xcntL[7] B=n_265 Y=n_284
Xg10611 INVx1_ASAP7_75t_SL $PINS A=n_282 Y=n_283
Xg10612 INVx1_ASAP7_75t_SL $PINS A=n_280 Y=n_281
Xg10613__9315 NAND2xp5_ASAP7_75t_SL $PINS A=n_261 B=n_14 Y=n_279
Xg10614__9945 NAND2xp5_ASAP7_75t_SL $PINS A=n_260 B=n_13 Y=n_278
Xg10617__2883 NOR2xp33_ASAP7_75t_SL $PINS A=n_82 B=n_267 Y=n_282
Xg10618__2346 NOR2xp33_ASAP7_75t_SL $PINS A=n_89 B=n_264 Y=n_280
Xg10626__1666 AND3x1_ASAP7_75t_SL $PINS A=n_240 B=coeffR_addr[4]
+ C=coeffR_addr[3] Y=n_277
Xg10627__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=n_217 A2=n_16 B1=rjL_addr[3]
+ B2=n_54 Y=n_276
Xg10628__6417 AOI22xp33_ASAP7_75t_SL $PINS A1=n_17 A2=n_215 B1=rjR_addr[3]
+ B2=n_53 Y=n_275
Xg10629__5477 AOI22xp5_ASAP7_75t_SL $PINS A1=n_214 A2=n_200 B1=xcntL[4]
+ B2=n_172 Y=n_274
Xg10630__2398 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_213 B1=xcntR[4] B2=n_70
+ Y=n_273
Xg10631__5107 AOI221xp5_ASAP7_75t_SL $PINS A1=n_200 A2=n_30 B1=n_172
+ B2=xcntL[0] C=n_142 Y=n_272
Xg10633__6260 XNOR2xp5_ASAP7_75t_SL $PINS A=n_87 B=n_246 Y=n_271
Xg10634__4319 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[6] B=n_247 Y=n_270
Xg10635__8428 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[6] B=n_242 Y=n_269
Xg10636__5526 XNOR2xp5_ASAP7_75t_SL $PINS A=n_78 B=n_245 Y=n_268
Xg10663__6783 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[5] B=n_206 Y=n_263
Xg10664__3680 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[5] B=n_208 Y=n_262
Xg10666__1617 XNOR2xp5_ASAP7_75t_SL $PINS A=n_471 B=n_209 Y=n_261
Xg10667__2802 XNOR2xp5_ASAP7_75t_SL $PINS A=n_479 B=n_205 Y=n_260
Xg10668__1705 AOI22xp5_ASAP7_75t_SL $PINS A1=n_465 A2=n_200 B1=xcntL[1]
+ B2=n_172 Y=n_259
Xg10669__5122 NAND2xp5_ASAP7_75t_SL $PINS A=n_1 B=n_13 Y=n_258
Xg10670__8246 NAND2xp5_ASAP7_75t_SL $PINS A=n_0 B=n_14 Y=n_257
Xg10671__7098 AOI21xp33_ASAP7_75t_SL $PINS A1=n_9 A2=n_211 B=n_459 Y=n_256
Xg10672__6131 AOI21xp33_ASAP7_75t_SL $PINS A1=n_10 A2=n_210 B=n_537 Y=n_255
Xg10673__1881 AOI22xp5_ASAP7_75t_SL $PINS A1=n_190 A2=n_16 B1=rjL_addr[2]
+ B2=n_54 Y=n_254
Xg10674__5115 AOI22xp5_ASAP7_75t_L $PINS A1=n_17 A2=n_188 B1=n_53
+ B2=rjR_addr[2] Y=n_253
Xg10675__7482 AOI22xp5_ASAP7_75t_SL $PINS A1=n_148 A2=n_200 B1=xcntL[2]
+ B2=n_172 Y=n_252
Xg10676__4733 AOI22xp5_ASAP7_75t_SL $PINS A1=n_187 A2=n_200 B1=xcntL[3]
+ B2=n_172 Y=n_251
Xg10677__6161 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_185 B1=xcntR[3] B2=n_70
+ Y=n_250
Xg10678__9315 NOR2xp33_ASAP7_75t_SL $PINS A=n_480 B=n_243 Y=n_249
Xg10680__9945 NOR2xp33_ASAP7_75t_SL $PINS A=n_472 B=n_244 Y=n_248
Xg10681__2883 NAND2xp5_ASAP7_75t_SL $PINS A=n_79 B=n_245 Y=n_267
Xg10682__2346 NOR2xp33_ASAP7_75t_SL $PINS A=n_27 B=n_242 Y=n_266
Xg10683__1666 NOR2xp33_ASAP7_75t_SL $PINS A=n_34 B=n_247 Y=n_265
Xg10684__7410 NAND2xp5_ASAP7_75t_SL $PINS A=n_88 B=n_246 Y=n_264
Xg10687__6417 OR2x2_ASAP7_75t_SL $PINS A=n_210 B=n_463 Y=n_241
Xg10688__5477 NOR5xp2_ASAP7_75t_SL $PINS A=n_192 B=n_116 C=n_102 D=n_101
+ E=n_100 Y=n_240
Xg10689__2398 AOI22xp33_ASAP7_75t_SL $PINS A1=n_17 A2=n_145 B1=rjR_addr[1]
+ B2=n_53 Y=n_239
Xg10690__5107 AOI22xp5_ASAP7_75t_SL $PINS A1=n_146 A2=n_16 B1=rjL_addr[1]
+ B2=n_54 Y=n_238
Xg10691__6260 NOR3xp33_ASAP7_75t_SL $PINS A=n_174 B=n_168 C=n_142 Y=n_237
Xg10692__4319 AOI221xp5_ASAP7_75t_SL $PINS A1=n_143 A2=start_workL B1=n_69
+ B2=n_25 C=n_174 Y=n_236
Xg10693__8428 NAND2xp5_ASAP7_75t_SL $PINS A=n_199 B=n_13 Y=n_235
Xg10694__5526 NAND2xp5_ASAP7_75t_SL $PINS A=n_191 B=n_14 Y=n_234
Xg10695__6783 OR2x2_ASAP7_75t_SL $PINS A=n_211 B=n_462 Y=n_233
Xg10698__3680 OR2x2_ASAP7_75t_SL $PINS A=n_28 B=n_208 Y=n_247
Xg10699__1617 NOR2xp33_ASAP7_75t_SL $PINS A=n_95 B=n_207 Y=n_246
Xg10700__2802 NOR2xp33_ASAP7_75t_SL $PINS A=n_96 B=n_204 Y=n_245
Xg10701__1705 NAND2xp5_ASAP7_75t_SL $PINS A=n_22 B=n_209 Y=n_244
Xg10702__5122 NAND2xp5_ASAP7_75t_SL $PINS A=n_24 B=n_205 Y=n_243
Xg10703__8246 OR2x2_ASAP7_75t_SL $PINS A=n_26 B=n_206 Y=n_242
Xg10709__7098 XNOR2xp5_ASAP7_75t_SL $PINS A=n_91 B=n_178 Y=n_232
Xg10710__6131 AOI22xp5_ASAP7_75t_SL $PINS A1=n_162 A2=n_11 B1=inputL_addr[1]
+ B2=n_533 Y=n_231
Xg10711__1881 AOI22xp5_ASAP7_75t_SL $PINS A1=n_159 A2=n_11 B1=inputL_addr[2]
+ B2=n_533 Y=n_230
Xg10712__5115 AOI22xp5_ASAP7_75t_SL $PINS A1=n_154 A2=n_11 B1=inputL_addr[3]
+ B2=n_533 Y=n_229
Xg10713__7482 AOI22xp5_ASAP7_75t_SL $PINS A1=n_161 A2=n_11 B1=inputL_addr[4]
+ B2=n_533 Y=n_228
Xg10714__4733 AOI22xp5_ASAP7_75t_SL $PINS A1=n_165 A2=n_11 B1=inputL_addr[5]
+ B2=n_533 Y=n_227
Xg10715__6161 AOI22xp5_ASAP7_75t_SL $PINS A1=n_163 A2=n_11 B1=inputL_addr[7]
+ B2=n_533 Y=n_226
Xg10716__9315 AOI22xp5_ASAP7_75t_SL $PINS A1=n_160 A2=n_12 B1=inputR_addr[1]
+ B2=n_531 Y=n_225
Xg10717__9945 AOI22xp5_ASAP7_75t_SL $PINS A1=n_156 A2=n_12 B1=inputR_addr[2]
+ B2=n_531 Y=n_224
Xg10718__2883 AOI22xp5_ASAP7_75t_SL $PINS A1=n_155 A2=n_12 B1=inputR_addr[3]
+ B2=n_531 Y=n_223
Xg10719__2346 AOI22xp5_ASAP7_75t_SL $PINS A1=n_153 A2=n_12 B1=inputR_addr[4]
+ B2=n_531 Y=n_222
Xg10720__1666 AOI22xp5_ASAP7_75t_SL $PINS A1=n_152 A2=n_12 B1=inputR_addr[5]
+ B2=n_531 Y=n_221
Xg10721__7410 AOI22xp5_ASAP7_75t_SL $PINS A1=n_151 A2=n_12 B1=inputR_addr[6]
+ B2=n_531 Y=n_220
Xg10722__6417 AOI22xp5_ASAP7_75t_SL $PINS A1=n_150 A2=n_12 B1=inputR_addr[7]
+ B2=n_531 Y=n_219
Xg10723__5477 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_157 B1=xcntR[2] B2=n_70
+ Y=n_218
Xg10726__2398 XOR2xp5_ASAP7_75t_SL $PINS A=n_83 B=n_177 Y=n_217
Xg10727__5107 XNOR2xp5_ASAP7_75t_SL $PINS A=n_84 B=n_179 Y=n_216
Xg10728__6260 XNOR2xp5_ASAP7_75t_SL $PINS A=n_93 B=n_180 Y=n_215
Xg10729__4319 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[4] B=n_173 Y=n_214
Xg10730__8428 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[4] B=n_181 Y=n_213
Xg10731__5526 AOI22xp5_ASAP7_75t_SL $PINS A1=n_158 A2=n_11 B1=inputL_addr[6]
+ B2=n_533 Y=n_212
Xg10734__6783 NAND2xp5_ASAP7_75t_SL $PINS A=n_164 B=n_14 Y=n_203
Xg10735__3680 NAND2xp5_ASAP7_75t_SL $PINS A=n_149 B=n_13 Y=n_202
Xg10736__1617 NAND2xp5_ASAP7_75t_SL $PINS A=sleep_flag B=n_183 Y=n_201
Xg10737__2802 NAND2xp5_ASAP7_75t_SL $PINS A=n_94 B=n_180 Y=n_211
Xg10738__1705 OR2x2_ASAP7_75t_SL $PINS A=n_83 B=n_177 Y=n_210
Xg10739__5122 NOR2xp33_ASAP7_75t_SL $PINS A=n_470 B=n_175 Y=n_209
Xg10740__8246 OR2x2_ASAP7_75t_SL $PINS A=n_31 B=n_173 Y=n_208
Xg10742__7098 NAND2xp5_ASAP7_75t_SL $PINS A=n_85 B=n_179 Y=n_207
Xg10743__6131 OR2x2_ASAP7_75t_SL $PINS A=n_37 B=n_181 Y=n_206
Xg10745__1881 NOR2xp33_ASAP7_75t_SL $PINS A=n_478 B=n_176 Y=n_205
Xg10746__5115 NAND2xp5_ASAP7_75t_SL $PINS A=n_92 B=n_178 Y=n_204
Xg10749 INVx1_ASAP7_75t_SL $PINS A=n_184 Y=n_200
Xg10750__7482 XNOR2xp5_ASAP7_75t_SL $PINS A=n_477 B=n_129 Y=n_199
Xg10751__4733 AOI22xp5_ASAP7_75t_SL $PINS A1=n_124 A2=n_11 B1=inputL_addr[0]
+ B2=n_533 Y=n_198
Xg10752__6161 AOI22xp5_ASAP7_75t_SL $PINS A1=n_123 A2=n_12 B1=inputR_addr[0]
+ B2=n_531 Y=n_197
Xg10753 AOI221xp5_ASAP7_75t_SL $PINS A1=n_70 A2=xcntR[0] B1=n_126 B2=n_33
+ C=n_121 Y=n_196
Xg10754 AOI22xp5_ASAP7_75t_SL $PINS A1=n_126 A2=n_464 B1=xcntR[1] B2=n_70
+ Y=n_195
Xg10755 NOR4xp25_ASAP7_75t_SL $PINS A=n_113 B=n_111 C=n_115 D=n_109 Y=n_194
Xg10756 NOR4xp25_ASAP7_75t_SL $PINS A=n_108 B=n_107 C=n_106 D=n_112 Y=n_193
Xg10757 NAND4xp25_ASAP7_75t_SL $PINS A=n_103 B=n_110 C=n_104 D=n_105 Y=n_192
Xg10758 XNOR2xp5_ASAP7_75t_SL $PINS A=n_469 B=n_139 Y=n_191
Xg10759 XNOR2xp5_ASAP7_75t_SL $PINS A=n_80 B=n_138 Y=n_190
Xg10760 XNOR2xp5_ASAP7_75t_SL $PINS A=n_56 B=n_135 Y=n_189
Xg10761 XNOR2xp5_ASAP7_75t_SL $PINS A=n_75 B=n_127 Y=n_188
Xg10762 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[3] B=n_134 Y=n_187
Xg10763 XNOR2xp5_ASAP7_75t_SL $PINS A=n_57 B=n_130 Y=n_186
Xg10764 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[3] B=n_137 Y=n_185
Xg10765 AOI21xp5_ASAP7_75t_SL $PINS A1=n_133 A2=en_FIR B=n_174 Y=n_184
Xg10766 INVx1_ASAP7_75t_SL $PINS A=n_182 Y=n_183
Xg10769 INVx1_ASAP7_75t_SL $PINS A=n_171 Y=n_172
Xg10770 NAND2xp5_ASAP7_75t_SL $PINS A=n_119 B=n_13 Y=n_170
Xg10771 NAND2xp5_ASAP7_75t_SL $PINS A=n_114 B=n_14 Y=n_169
Xg10772 NOR2xp33_ASAP7_75t_SL $PINS A=sleep_flag B=n_132 Y=n_168
Xg10773 AOI22xp33_ASAP7_75t_SL $PINS A1=n_53 A2=rjR_addr[0] B1=n_72 B2=n_17
+ Y=n_167
Xg10774 AOI22xp33_ASAP7_75t_SL $PINS A1=n_54 A2=rjL_addr[0] B1=n_73 B2=n_16
+ Y=n_166
Xg10777 NOR2xp33_ASAP7_75t_SL $PINS A=n_140 B=n_133 Y=n_182
Xg10780 OR2x2_ASAP7_75t_SL $PINS A=n_35 B=n_137 Y=n_181
Xg10782 NOR2xp33_ASAP7_75t_SL $PINS A=n_75 B=n_128 Y=n_180
Xg10783 NOR2xp33_ASAP7_75t_SL $PINS A=n_56 B=n_136 Y=n_179
Xg10784 NOR2xp33_ASAP7_75t_SL $PINS A=n_57 B=n_131 Y=n_178
Xg10785 NAND2xp5_ASAP7_75t_SL $PINS A=n_81 B=n_138 Y=n_177
Xg10787 NAND2xp5_ASAP7_75t_SL $PINS A=n_19 B=n_129 Y=n_176
Xg10788 NAND2xp5_ASAP7_75t_SL $PINS A=n_21 B=n_139 Y=n_175
Xg10789 NOR2xp33_ASAP7_75t_SL $PINS A=sleep_flag B=n_141 Y=n_174
Xg10790 OR2x2_ASAP7_75t_SL $PINS A=n_29 B=n_134 Y=n_173
Xg10791 AOI221xp5_ASAP7_75t_SL $PINS A1=n_25 A2=n_18 B1=next_stateL[1]
+ B2=sleep_flag C=n_143 Y=n_171
Xg10792 XNOR2xp5_ASAP7_75t_SL $PINS A=n_50 B=n_451 Y=n_165
Xg10793 XNOR2xp5_ASAP7_75t_SL $PINS A=n_468 B=n_61 Y=n_164
Xg10794 XNOR2xp5_ASAP7_75t_SL $PINS A=n_43 B=n_449 Y=n_163
Xg10795 XNOR2xp5_ASAP7_75t_SL $PINS A=n_457 B=n_41 Y=n_162
Xg10796 XNOR2xp5_ASAP7_75t_SL $PINS A=n_42 B=n_455 Y=n_161
Xg10797 XNOR2xp5_ASAP7_75t_SL $PINS A=n_458 B=n_40 Y=n_160
Xg10798 XNOR2xp5_ASAP7_75t_SL $PINS A=n_456 B=n_44 Y=n_159
Xg10799 XNOR2xp5_ASAP7_75t_SL $PINS A=n_47 B=n_450 Y=n_158
Xg10800 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntR[2] B=n_64 Y=n_157
Xg10801 XNOR2xp5_ASAP7_75t_SL $PINS A=n_445 B=n_48 Y=n_156
Xg10802 XNOR2xp5_ASAP7_75t_SL $PINS A=n_46 B=n_453 Y=n_155
Xg10803 XNOR2xp5_ASAP7_75t_SL $PINS A=n_52 B=n_452 Y=n_154
Xg10804 XNOR2xp5_ASAP7_75t_SL $PINS A=n_49 B=n_454 Y=n_153
Xg10805 XNOR2xp5_ASAP7_75t_SL $PINS A=n_45 B=n_446 Y=n_152
Xg10806 XNOR2xp5_ASAP7_75t_SL $PINS A=n_39 B=n_447 Y=n_151
Xg10807 XNOR2xp5_ASAP7_75t_SL $PINS A=n_51 B=n_448 Y=n_150
Xg10808 XNOR2xp5_ASAP7_75t_SL $PINS A=n_476 B=n_58 Y=n_149
Xg10809 XNOR2xp5_ASAP7_75t_SL $PINS A=xcntL[2] B=n_60 Y=n_148
Xg10810 XOR2xp5_ASAP7_75t_SL $PINS A=n_74 B=n_55 Y=n_147
Xg10811 XOR2xp5_ASAP7_75t_SL $PINS A=n_77 B=n_73 Y=n_146
Xg10812 XOR2xp5_ASAP7_75t_SL $PINS A=n_63 B=n_72 Y=n_145
Xg10813 XOR2xp5_ASAP7_75t_SL $PINS A=n_71 B=n_97 Y=n_144
Xg10814 INVx1_ASAP7_75t_SL $PINS A=n_140 Y=n_141
Xg10815 INVx1_ASAP7_75t_SL $PINS A=n_135 Y=n_136
Xg10816 INVx1_ASAP7_75t_SL $PINS A=n_132 Y=n_133
Xg10817 INVx1_ASAP7_75t_SL $PINS A=n_130 Y=n_131
Xg10818 INVx1_ASAP7_75t_SL $PINS A=n_127 Y=n_128
Xg10819 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffdataL[8] A2=n_13 B1=addsubL
+ B2=n_460 Y=n_125
Xg10820 OAI21xp33_ASAP7_75t_SL $PINS A1=coeffdataL[0] A2=xcntL[0] B=n_457
+ Y=n_124
Xg10821 OAI21xp33_ASAP7_75t_SL $PINS A1=coeffdataR[0] A2=xcntR[0] B=n_458
+ Y=n_123
Xg10822 AOI21xp33_ASAP7_75t_SL $PINS A1=Clear A2=start_workR B=n_69 Y=n_122
Xg10823 NOR2xp33_ASAP7_75t_SL $PINS A=next_stateR[0] B=n_70 Y=n_121
Xg10824 NOR2xp33_ASAP7_75t_SL $PINS A=n_90 B=n_69 Y=n_120
Xg10825 OAI21xp5_ASAP7_75t_SL $PINS A1=n_25 A2=n_38 B=n_15 Y=n_143
Xg10826 NOR2xp33_ASAP7_75t_SL $PINS A=n_70 B=n_65 Y=n_142
Xg10827 NOR3xp33_ASAP7_75t_SL $PINS A=n_25 B=next_stateL[0] C=Clear Y=n_140
Xg10828 NOR2xp33_ASAP7_75t_SL $PINS A=n_468 B=n_62 Y=n_139
Xg10829 NOR2xp33_ASAP7_75t_SL $PINS A=n_77 B=n_73 Y=n_138
Xg10830 OR2x2_ASAP7_75t_SL $PINS A=n_32 B=n_64 Y=n_137
Xg10831 NOR2xp33_ASAP7_75t_SL $PINS A=n_55 B=n_74 Y=n_135
Xg10832 OR2x2_ASAP7_75t_SL $PINS A=n_36 B=n_60 Y=n_134
Xg10833 NAND3xp33_ASAP7_75t_SL $PINS A=n_25 B=next_stateL[0] C=n_15 Y=n_132
Xg10834 NOR2xp33_ASAP7_75t_SL $PINS A=n_97 B=n_71 Y=n_130
Xg10835 NOR2xp33_ASAP7_75t_SL $PINS A=n_476 B=n_59 Y=n_129
Xg10836 NOR2xp33_ASAP7_75t_SL $PINS A=n_63 B=n_72 Y=n_127
Xg10839 AND2x2_ASAP7_75t_SL $PINS A=next_stateR[0] B=n_69 Y=n_126
Xg10840 XOR2xp5_ASAP7_75t_SL $PINS A=n_475 B=n_474 Y=n_119
Xg10841 AOI22xp5_ASAP7_75t_SL $PINS A1=rjL_enable A2=n_23 B1=start_workL B2=VDD
+ Y=n_118
Xg10842 AOI22xp5_ASAP7_75t_SL $PINS A1=rjR_enable A2=n_20 B1=start_workR B2=VDD
+ Y=n_117
Xg10843 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[3] B=kR[3] Y=n_116
Xg10844 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[5] B=kL[5] Y=n_115
Xg10845 XOR2xp5_ASAP7_75t_SL $PINS A=n_467 B=n_466 Y=n_114
Xg10846 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[7] B=kL[7] Y=n_113
Xg10847 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[0] B=kL[0] Y=n_112
Xg10848 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[6] B=kL[6] Y=n_111
Xg10849 XNOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[7] B=kR[7] Y=n_110
Xg10850 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[4] B=kL[4] Y=n_109
Xg10851 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[3] B=kL[3] Y=n_108
Xg10852 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[1] B=kL[1] Y=n_107
Xg10853 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataL[2] B=kL[2] Y=n_106
Xg10854 XNOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[6] B=kR[6] Y=n_105
Xg10855 XNOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[5] B=kR[5] Y=n_104
Xg10856 XNOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[4] B=kR[4] Y=n_103
Xg10857 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[1] B=kR[1] Y=n_102
Xg10858 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[2] B=kR[2] Y=n_101
Xg10859 XOR2xp5_ASAP7_75t_SL $PINS A=rjdataR[0] B=kR[0] Y=n_100
Xg10860 AOI22xp5_ASAP7_75t_SL $PINS A1=coeffdataR[8] A2=n_14 B1=addsubR
+ B2=n_461 Y=n_99
Xg10861 INVx1_ASAP7_75t_SL $PINS A=n_93 Y=n_94
Xg10862 INVx1_ASAP7_75t_SL $PINS A=n_91 Y=n_92
Xg10863 INVx1_ASAP7_75t_SL $PINS A=n_87 Y=n_88
Xg10864 INVx1_ASAP7_75t_SL $PINS A=n_84 Y=n_85
Xg10865 INVx1_ASAP7_75t_SL $PINS A=n_80 Y=n_81
Xg10866 INVx1_ASAP7_75t_SL $PINS A=n_78 Y=n_79
Xg10867 INVx1_ASAP7_75t_SL $PINS A=n_70 Y=n_69
Xg10868 NAND2xp5_ASAP7_75t_SL $PINS A=n_466 B=n_14 Y=n_68
Xg10869 NAND2xp5_ASAP7_75t_SL $PINS A=n_474 B=n_13 Y=n_67
Xg10870 AND2x2_ASAP7_75t_SL $PINS A=coeffL_addr[8] B=n_10 Y=n_98
Xg10871 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[1] B=n_10 Y=n_97
Xg10872 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[4] B=n_10 Y=n_96
Xg10873 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[4] B=n_9 Y=n_95
Xg10874 NAND2xp5_ASAP7_75t_SL $PINS A=rjR_addr[3] B=n_9 Y=n_93
Xg10875 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[3] B=n_10 Y=n_91
Xg10876 AND2x2_ASAP7_75t_SL $PINS A=n_15 B=next_stateR[0] Y=n_90
Xg10877 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[6] B=n_9 Y=n_89
Xg10878 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[5] B=n_9 Y=n_87
Xg10879 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[7] B=n_9 Y=n_86
Xg10880 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[3] B=n_9 Y=n_84
Xg10881 NAND2xp5_ASAP7_75t_SL $PINS A=rjL_addr[3] B=n_10 Y=n_83
Xg10882 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[6] B=n_10 Y=n_82
Xg10883 NAND2xp5_ASAP7_75t_SL $PINS A=rjL_addr[2] B=n_10 Y=n_80
Xg10884 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[5] B=n_10 Y=n_78
Xg10885 NAND2xp5_ASAP7_75t_SL $PINS A=rjL_addr[1] B=n_10 Y=n_77
Xg10886 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[7] B=n_10 Y=n_76
Xg10887 NAND2xp5_ASAP7_75t_SL $PINS A=rjR_addr[2] B=n_9 Y=n_75
Xg10888 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[0] B=n_9 Y=n_74
Xg10889 NAND2xp5_ASAP7_75t_SL $PINS A=rjL_addr[0] B=n_10 Y=n_73
Xg10890 NAND2xp5_ASAP7_75t_SL $PINS A=rjR_addr[0] B=n_9 Y=n_72
Xg10891 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[0] B=n_10 Y=n_71
Xg10892 NAND2xp5_ASAP7_75t_SL $PINS A=en_FIR B=n_15 Y=n_70
Xg10893 INVx1_ASAP7_75t_SL $PINS A=n_61 Y=n_62
Xg10894 INVx1_ASAP7_75t_SL $PINS A=n_58 Y=n_59
Xg10895 NAND2xp5_ASAP7_75t_SL $PINS A=n_426 B=n_436 Y=n_52
Xg10896 NAND2xp5_ASAP7_75t_SL $PINS A=n_418 B=n_443 Y=n_51
Xg10897 AND2x2_ASAP7_75t_SL $PINS A=coeffR_addr[8] B=n_9 Y=n_66
Xg10898 NAND2xp5_ASAP7_75t_SL $PINS A=n_435 B=n_422 Y=n_50
Xg10899 NAND2xp5_ASAP7_75t_SL $PINS A=n_441 B=n_423 Y=n_49
Xg10900 NAND2xp5_ASAP7_75t_SL $PINS A=n_433 B=n_427 Y=n_48
Xg10901 NAND2xp5_ASAP7_75t_SL $PINS A=n_419 B=n_432 Y=n_47
Xg10902 NAND2xp5_ASAP7_75t_SL $PINS A=n_425 B=n_438 Y=n_46
Xg10903 NAND2xp5_ASAP7_75t_SL $PINS A=n_431 B=n_421 Y=n_45
Xg10904 NAND2xp5_ASAP7_75t_SL $PINS A=n_437 B=n_428 Y=n_44
Xg10905 NAND2xp5_ASAP7_75t_SL $PINS A=n_417 B=n_444 Y=n_43
Xg10906 NAND2xp5_ASAP7_75t_SL $PINS A=n_440 B=n_424 Y=n_42
Xg10907 NAND2xp5_ASAP7_75t_SL $PINS A=n_38 B=n_25 Y=n_65
Xg10908 NAND2xp5_ASAP7_75t_SL $PINS A=n_429 B=n_439 Y=n_41
Xg10909 NAND2xp5_ASAP7_75t_SL $PINS A=n_430 B=n_434 Y=n_40
Xg10910 NAND2xp5_ASAP7_75t_SL $PINS A=n_420 B=n_442 Y=n_39
Xg10911 NAND2xp5_ASAP7_75t_SL $PINS A=xcntR[1] B=xcntR[0] Y=n_64
Xg10912 NAND2xp5_ASAP7_75t_SL $PINS A=rjR_addr[1] B=n_9 Y=n_63
Xg10913 NOR2xp33_ASAP7_75t_SL $PINS A=n_467 B=n_466 Y=n_61
Xg10914 NAND2xp5_ASAP7_75t_SL $PINS A=xcntL[1] B=xcntL[0] Y=n_60
Xg10915 NOR2xp33_ASAP7_75t_SL $PINS A=n_475 B=n_474 Y=n_58
Xg10916 NAND2xp5_ASAP7_75t_SL $PINS A=coeffL_addr[2] B=n_10 Y=n_57
Xg10917 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[2] B=n_9 Y=n_56
Xg10918 NAND2xp5_ASAP7_75t_SL $PINS A=coeffR_addr[1] B=n_9 Y=n_55
Xg10919 NOR2xp33_ASAP7_75t_SL $PINS A=outL B=n_460 Y=n_54
Xg10920 NOR2xp33_ASAP7_75t_SL $PINS A=outR B=n_461 Y=n_53
Xg10943 INVxp67_ASAP7_75t_SL $PINS A=next_stateL[0] Y=n_38
Xg10946 INVxp67_ASAP7_75t_SL $PINS A=xcntR[4] Y=n_37
Xg10948 INVxp67_ASAP7_75t_SL $PINS A=xcntL[2] Y=n_36
Xg10950 INVxp67_ASAP7_75t_SL $PINS A=xcntR[3] Y=n_35
Xg10952 INVxp67_ASAP7_75t_SL $PINS A=xcntL[6] Y=n_34
Xg10953 INVxp67_ASAP7_75t_SL $PINS A=xcntR[0] Y=n_33
Xg10957 INVxp67_ASAP7_75t_SL $PINS A=xcntR[2] Y=n_32
Xg10959 INVxp67_ASAP7_75t_SL $PINS A=xcntL[4] Y=n_31
Xg10960 INVx1_ASAP7_75t_SL $PINS A=xcntL[0] Y=n_30
Xg10964 INVxp67_ASAP7_75t_SL $PINS A=xcntL[3] Y=n_29
Xg10966 INVxp67_ASAP7_75t_SL $PINS A=xcntL[5] Y=n_28
Xg10968 INVxp67_ASAP7_75t_SL $PINS A=xcntR[6] Y=n_27
Xg10971 INVxp67_ASAP7_75t_SL $PINS A=xcntR[5] Y=n_26
Xg10972 INVx1_ASAP7_75t_SL $PINS A=next_stateL[1] Y=n_25
Xg10985 INVxp67_ASAP7_75t_SL $PINS A=outL Y=n_10
Xg10998 INVxp67_ASAP7_75t_SL $PINS A=outR Y=n_9
Xg10999 INVx1_ASAP7_75t_SL $PINS A=n_479 Y=n_24
Xg11000 INVxp67_ASAP7_75t_SL $PINS A=n_483 Y=n_23
Xg11001 INVx1_ASAP7_75t_SL $PINS A=n_471 Y=n_22
Xg11002 INVx1_ASAP7_75t_SL $PINS A=n_469 Y=n_21
Xg11003 INVxp67_ASAP7_75t_SL $PINS A=n_482 Y=n_20
Xg11004 INVx1_ASAP7_75t_SL $PINS A=n_477 Y=n_19
Xg11005 INVxp67_ASAP7_75t_SL $PINS A=en_FIR Y=n_18
Xg11006 INVx1_ASAP7_75t_SL $PINS A=n_462 Y=n_17
Xg11007 INVx1_ASAP7_75t_SL $PINS A=n_463 Y=n_16
Xg11008 INVx1_ASAP7_75t_SL $PINS A=Clear Y=n_15
Xg11009 INVx1_ASAP7_75t_SL $PINS A=n_461 Y=n_14
Xg11010 INVx1_ASAP7_75t_SL $PINS A=n_460 Y=n_13
Xg11011 INVx1_ASAP7_75t_SL $PINS A=n_531 Y=n_12
Xg11012 INVx1_ASAP7_75t_SL $PINS A=n_533 Y=n_11
Xg2 XOR2xp5_ASAP7_75t_SL $PINS A=n_82 B=n_267 Y=n_8
Xg11013 XOR2xp5_ASAP7_75t_SL $PINS A=xcntR[7] B=n_266 Y=n_7
Xg11014 XOR2xp5_ASAP7_75t_SL $PINS A=n_89 B=n_264 Y=n_6
Xg11015 XOR2xp5_ASAP7_75t_SL $PINS A=n_472 B=n_244 Y=n_5
Xg11016 XOR2xp5_ASAP7_75t_SL $PINS A=n_480 B=n_243 Y=n_4
Xg11017 XOR2xp5_ASAP7_75t_SL $PINS A=n_95 B=n_207 Y=n_3
Xg11018 XOR2xp5_ASAP7_75t_SL $PINS A=n_96 B=n_204 Y=n_2
Xg11019 XOR2xp5_ASAP7_75t_SL $PINS A=n_478 B=n_176 Y=n_1
Xg11020 XOR2xp5_ASAP7_75t_SL $PINS A=n_470 B=n_175 Y=n_0
.ENDS

.SUBCKT main_controller Sclk Dclk Start Reset_n Frame input_ready allzeros_L
+ allzeros_R Rj_Read_Address[3] Rj_Read_Address[2] Rj_Read_Address[1]
+ Rj_Read_Address[0] Coefficient_Read_Address[8] Coefficient_Read_Address[7]
+ Coefficient_Read_Address[6] Coefficient_Read_Address[5]
+ Coefficient_Read_Address[4] Coefficient_Read_Address[3]
+ Coefficient_Read_Address[2] Coefficient_Read_Address[1]
+ Coefficient_Read_Address[0] Input_Read_Address[7] Input_Read_Address[6]
+ Input_Read_Address[5] Input_Read_Address[4] Input_Read_Address[3]
+ Input_Read_Address[2] Input_Read_Address[1] Input_Read_Address[0] en_FIR
+ sleep_flag InReady Rj_Read_Enable Coefficient_Read_Enable Data_Read_Enable
+ Clear Frame_out Dclk_out Sclk_out
*.CONNECT Sclk_out VSS
*.CONNECT Dclk_out VSS
*.CONNECT Frame_out VSS
*.CONNECT Data_Read_Enable VSS
XClear_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_130 QN=Clear
XCoefficient_Read_Address_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_166
+ QN=Coefficient_Read_Address[0]
XCoefficient_Read_Address_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_155
+ QN=Coefficient_Read_Address[1]
XCoefficient_Read_Address_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_156
+ QN=Coefficient_Read_Address[2]
XCoefficient_Read_Address_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_163
+ QN=Coefficient_Read_Address[3]
XCoefficient_Read_Address_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_153
+ QN=Coefficient_Read_Address[4]
XCoefficient_Read_Address_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_152
+ QN=Coefficient_Read_Address[5]
XCoefficient_Read_Address_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_151
+ QN=Coefficient_Read_Address[6]
XCoefficient_Read_Address_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_150
+ QN=Coefficient_Read_Address[7]
XCoefficient_Read_Address_reg[8] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_148
+ QN=Coefficient_Read_Address[8]
XCoefficient_Read_Enable_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_165
+ QN=Coefficient_Read_Enable
XData_Read_Enable_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_170 QN=en_FIR
XInReady_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_142 QN=InReady
XInput_Read_Address_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_189
+ QN=Input_Read_Address[0]
XInput_Read_Address_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_185
+ QN=Input_Read_Address[1]
XInput_Read_Address_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_184
+ QN=Input_Read_Address[2]
XInput_Read_Address_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_183
+ QN=Input_Read_Address[3]
XInput_Read_Address_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_182
+ QN=Input_Read_Address[4]
XInput_Read_Address_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_181
+ QN=Input_Read_Address[5]
XInput_Read_Address_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_180
+ QN=Input_Read_Address[6]
XInput_Read_Address_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_179
+ QN=Input_Read_Address[7]
XRj_Read_Address_reg[0] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_157
+ QN=Rj_Read_Address[0]
XRj_Read_Address_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_149
+ QN=Rj_Read_Address[1]
XRj_Read_Address_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_147
+ QN=Rj_Read_Address[2]
XRj_Read_Address_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_158
+ QN=Rj_Read_Address[3]
XRj_Read_Enable_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_169
+ QN=Rj_Read_Enable
Xcount_coeff_reg[0] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_99 SE=count_coeff[0]
+ SI=n_109 QN=count_coeff[0]
Xcount_coeff_reg[1] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_129
+ SE=count_coeff[1] SI=n_134 QN=count_coeff[1]
Xcount_coeff_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_206
+ QN=count_coeff[2]
Xcount_coeff_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_211
+ QN=count_coeff[3]
Xcount_coeff_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_218
+ QN=count_coeff[4]
Xcount_coeff_reg[5] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_224
+ QN=count_coeff[5]
Xcount_coeff_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_227
+ QN=count_coeff[6]
Xcount_coeff_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_228
+ QN=count_coeff[7]
Xcount_coeff_reg[8] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_230
+ QN=count_coeff[8]
Xcount_coeff_reg[9] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_219
+ QN=count_coeff[9]
Xcount_data_reg[0] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_144 SE=count_data[0]
+ SI=n_115 QN=count_data[0]
Xcount_data_reg[1] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_175 SE=count_data[1]
+ SI=n_141 QN=count_data[1]
Xcount_data_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_192
+ QN=count_data[2]
Xcount_data_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_191
+ QN=count_data[3]
Xcount_data_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_187
+ QN=count_data[4]
Xcount_data_reg[5] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_164 SE=count_data[5]
+ SI=n_177 QN=count_data[5]
Xcount_data_reg[6] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_209
+ QN=count_data[6]
Xcount_data_reg[7] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_215
+ QN=count_data[7]
Xcount_rj_reg[0] SDFHx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_102 SE=count_rj[0]
+ SI=n_89 QN=count_rj[0]
Xcount_rj_reg[1] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_168 QN=count_rj[1]
Xcount_rj_reg[2] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_193 QN=count_rj[2]
Xcount_rj_reg[3] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_201 QN=count_rj[3]
Xcount_rj_reg[4] DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_132 QN=count_rj[4]
Xsleep_flag_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_159 QN=sleep_flag
Xstate_next_reg[0] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_2 SET=VSS CLK=Sclk
+ D=n_233 QN=state_next[0]
Xstate_next_reg[1] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_2 SET=VSS CLK=Sclk
+ D=n_203 QN=state_next[1]
Xstate_next_reg[2] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_2 SET=VSS CLK=Sclk
+ D=n_194 QN=state_next[2]
Xstate_next_reg[3] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_2 SET=VSS CLK=Sclk
+ D=n_135 QN=state_next[3]
Xstate_present_reg[0] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_120 SET=n_94
+ CLK=Sclk D=n_23 QN=state_present[0]
Xstate_present_reg[1] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_122 SET=n_95
+ CLK=Sclk D=n_24 QN=state_present[1]
Xstate_present_reg[2] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_121 SET=n_93
+ CLK=Sclk D=n_25 QN=state_present[2]
Xstate_present_reg[3] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=n_91 SET=n_124
+ CLK=Sclk D=n_22 QN=state_present[3]
Xtk_reg DFFHQNx1_ASAP7_75t_SL $PINS CLK=Sclk D=n_213 QN=tk
Xg6729 AOI221xp5_ASAP7_75t_SL $PINS A1=n_76 A2=state_next[0] B1=n_50 B2=n_37
+ C=n_232 Y=n_233
Xg6730 OAI21xp5_ASAP7_75t_SL $PINS A1=state_present[0] A2=n_190 B=n_231 Y=n_232
Xg6732 AOI321xp33_ASAP7_75t_SL $PINS A1=n_214 A2=n_42 A3=n_17 B1=n_31 B2=n_65
+ C=n_229 Y=n_231
Xg6734 AOI21xp5_ASAP7_75t_SL $PINS A1=count_coeff[8] A2=n_226 B=n_225 Y=n_230
Xg6736 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=Frame A2=n_16 B=n_221
+ C=state_present[3] Y=n_229
Xg6737 AOI21xp5_ASAP7_75t_SL $PINS A1=count_coeff[7] A2=n_223 B=n_220 Y=n_228
Xg6740 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_27 A2=n_210 B=count_coeff[6] C=n_217
+ Y=n_227
Xg6741 OAI21xp5_ASAP7_75t_SL $PINS A1=count_coeff[7] A2=n_13 B=n_222 Y=n_226
Xg6742 NOR4xp25_ASAP7_75t_SL $PINS A=n_212 B=n_17 C=count_coeff[8] D=n_49
+ Y=n_225
Xg6743 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_27 A2=n_200 B=count_coeff[5] C=n_208
+ Y=n_224
Xg6747 INVxp67_ASAP7_75t_SL $PINS A=n_222 Y=n_223
Xg6748 OR3x1_ASAP7_75t_SL $PINS A=n_212 B=n_17 C=n_19 Y=n_221
Xg6749 NOR3xp33_ASAP7_75t_SL $PINS A=n_212 B=count_coeff[7] C=n_49 Y=n_220
Xg6750 AOI21xp5_ASAP7_75t_SL $PINS A1=count_coeff[9] A2=n_51 B=n_216 Y=n_219
Xg6751 AOI21xp5_ASAP7_75t_SL $PINS A1=n_212 A2=state_present[2] B=n_27 Y=n_222
Xg6752 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_27 A2=n_196 B=count_coeff[4] C=n_205
+ Y=n_218
Xg6753 NOR3xp33_ASAP7_75t_SL $PINS A=n_207 B=count_coeff[6] C=n_49 Y=n_217
Xg6756 NOR5xp2_ASAP7_75t_SL $PINS A=n_172 B=n_40 C=n_41 D=n_17 E=n_49 Y=n_216
Xg6757 AOI22xp5_ASAP7_75t_SL $PINS A1=n_204 A2=count_data[7] B1=n_202
+ B2=count_data[5] Y=n_215
Xg6758 NOR5xp2_ASAP7_75t_SL $PINS A=n_161 B=count_coeff[6] C=count_coeff[5]
+ D=count_coeff[4] E=count_coeff[3] Y=n_214
Xg6759 AOI322xp5_ASAP7_75t_SL $PINS A1=n_43 A2=n_13 A3=tk B1=n_138 B2=tk
+ C1=n_188 C2=input_ready Y=n_213
Xg6765 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_27 A2=n_167 B=count_coeff[3] C=n_186
+ Y=n_211
Xg6766 AND2x2_ASAP7_75t_SL $PINS A=state_present[2] B=n_207 Y=n_210
Xg6767 AOI22xp5_ASAP7_75t_SL $PINS A1=n_197 A2=count_data[6] B1=n_195
+ B2=count_data[5] Y=n_209
Xg6768 NOR3xp33_ASAP7_75t_SL $PINS A=n_199 B=count_coeff[5] C=n_49 Y=n_208
Xg6769 OR2x2_ASAP7_75t_SL $PINS A=n_7 B=n_207 Y=n_212
Xg6781 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_27 A2=n_143 B=count_coeff[2] C=n_160
+ Y=n_206
Xg6782 NOR3xp33_ASAP7_75t_SL $PINS A=n_174 B=count_coeff[4] C=n_49 Y=n_205
Xg6783 OAI21xp5_ASAP7_75t_SL $PINS A1=count_data[6] A2=n_68 B=n_198 Y=n_204
Xg6784 AOI221xp5_ASAP7_75t_SL $PINS A1=n_81 A2=n_86 B1=n_76 B2=state_next[1]
+ C=n_178 Y=n_203
Xg6785 NOR3xp33_ASAP7_75t_SL $PINS A=n_9 B=count_data[7] C=n_164 Y=n_202
Xg6786 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_79 A2=n_140 B=count_rj[3] C=n_162
+ Y=n_201
Xg6787 AND2x2_ASAP7_75t_SL $PINS A=state_present[2] B=n_199 Y=n_200
Xg6790 OR2x2_ASAP7_75t_SL $PINS A=n_5 B=n_199 Y=n_207
Xg6810 OR2x2_ASAP7_75t_SL $PINS A=n_3 B=n_174 Y=n_199
Xg6813 INVxp67_ASAP7_75t_SL $PINS A=n_197 Y=n_198
Xg6814 AND2x2_ASAP7_75t_SL $PINS A=state_present[2] B=n_174 Y=n_196
Xg6815 NOR2xp33_ASAP7_75t_SL $PINS A=n_164 B=count_data[6] Y=n_195
Xg6816 AOI321xp33_ASAP7_75t_SL $PINS A1=n_43 A2=n_15 A3=Frame B1=n_81 B2=n_86
+ C=n_131 Y=n_194
Xg6817 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_79 A2=n_119 B=count_rj[2] C=n_133
+ Y=n_193
Xg6818 AOI21xp5_ASAP7_75t_SL $PINS A1=count_data[2] A2=n_137 B=n_173 Y=n_192
Xg6819 AOI21xp5_ASAP7_75t_SL $PINS A1=count_data[3] A2=n_136 B=n_171 Y=n_191
Xg6820 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=count_rj[3] A2=n_125 B=n_112 C=n_36
+ Y=n_190
Xg6821 AOI21xp5_ASAP7_75t_SL $PINS A1=Input_Read_Address[0] A2=n_114 B=n_176
+ Y=n_189
Xg6822 OAI332xp33_ASAP7_75t_SL $PINS A1=n_45 A2=n_118 A3=n_1 B1=n_40
+ B2=count_coeff[9] B3=n_49 C1=count_rj[4] C2=n_74 Y=n_188
Xg6823 AOI21xp5_ASAP7_75t_SL $PINS A1=count_data[4] A2=n_139 B=n_154 Y=n_187
Xg6824 NOR3xp33_ASAP7_75t_SL $PINS A=n_146 B=count_coeff[3] C=n_49 Y=n_186
Xg6825 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[1] A2=n_114 B1=n_145
+ B2=count_data[1] Y=n_185
Xg6826 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[2] A2=n_114 B1=n_145
+ B2=count_data[2] Y=n_184
Xg6827 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[3] A2=n_114 B1=n_145
+ B2=count_data[3] Y=n_183
Xg6828 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[4] A2=n_114 B1=n_145
+ B2=count_data[4] Y=n_182
Xg6829 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[5] A2=n_114 B1=n_145
+ B2=count_data[5] Y=n_181
Xg6830 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[6] A2=n_114 B1=n_145
+ B2=count_data[6] Y=n_180
Xg6831 AOI22xp33_ASAP7_75t_SL $PINS A1=Input_Read_Address[7] A2=n_114 B1=n_145
+ B2=count_data[7] Y=n_179
Xg6832 OAI321xp33_ASAP7_75t_SL $PINS A1=n_32 A2=n_16 A3=Reset_n
+ B1=state_present[3] B2=n_113 C=n_73 Y=n_178
Xg6833 OAI21xp5_ASAP7_75t_SL $PINS A1=count_data[5] A2=n_68 B=n_177 Y=n_197
Xg6834 INVx1_ASAP7_75t_SL $PINS A=n_175 Y=n_176
Xg6835 NOR3xp33_ASAP7_75t_SL $PINS A=n_46 B=count_data[2] C=n_144 Y=n_173
Xg6836 OR5x1_ASAP7_75t_SL $PINS A=n_66 B=n_19 C=n_7 D=n_5 E=n_3 Y=n_172
Xg6837 NOR3xp33_ASAP7_75t_SL $PINS A=n_55 B=count_data[3] C=n_144 Y=n_171
Xg6838 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_101 A2=n_90 B=en_FIR C=n_145 Y=n_170
Xg6839 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_101 A2=n_63 B=Rj_Read_Enable C=n_103
+ Y=n_169
Xg6840 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_79 A2=n_97 B=count_rj[1] C=n_110
+ Y=n_168
Xg6841 AND2x2_ASAP7_75t_SL $PINS A=state_present[2] B=n_146 Y=n_167
Xg6842 AOI21xp5_ASAP7_75t_SL $PINS A1=Coefficient_Read_Address[0] A2=n_116
+ B=n_128 Y=n_166
Xg6843 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_101 A2=n_60
+ B=Coefficient_Read_Enable C=n_100 Y=n_165
Xg6844 AOI21xp5_ASAP7_75t_SL $PINS A1=n_69 A2=n_21 B=n_139 Y=n_177
Xg6846 NAND2xp5_ASAP7_75t_SL $PINS A=n_145 B=count_data[0] Y=n_175
Xg6848 OR2x2_ASAP7_75t_SL $PINS A=n_20 B=n_146 Y=n_174
Xg6852 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[3]
+ B1=n_100 B2=count_coeff[3] Y=n_163
Xg6853 NOR3xp33_ASAP7_75t_SL $PINS A=n_126 B=count_rj[3] C=n_74 Y=n_162
Xg6854 OR5x1_ASAP7_75t_SL $PINS A=n_72 B=count_coeff[2] C=count_coeff[8]
+ D=count_coeff[1] E=count_coeff[0] Y=n_161
Xg6855 NOR3xp33_ASAP7_75t_SL $PINS A=n_127 B=count_coeff[2] C=n_49 Y=n_160
Xg6856 AOI222xp33_ASAP7_75t_SL $PINS A1=n_48 A2=n_106 B1=n_85 B2=n_108 C1=n_101
+ C2=sleep_flag Y=n_159
Xg6857 AOI22xp5_ASAP7_75t_SL $PINS A1=n_117 A2=Rj_Read_Address[3] B1=n_103
+ B2=count_rj[3] Y=n_158
Xg6858 AOI22xp5_ASAP7_75t_SL $PINS A1=n_117 A2=Rj_Read_Address[0] B1=n_75
+ B2=n_78 Y=n_157
Xg6859 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[2]
+ B1=n_100 B2=count_coeff[2] Y=n_156
Xg6860 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[1]
+ B1=n_100 B2=count_coeff[1] Y=n_155
Xg6861 NOR3xp33_ASAP7_75t_SL $PINS A=n_83 B=count_data[4] C=n_144 Y=n_154
Xg6862 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[4]
+ B1=n_100 B2=count_coeff[4] Y=n_153
Xg6863 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[5]
+ B1=n_100 B2=count_coeff[5] Y=n_152
Xg6864 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[6]
+ B1=n_100 B2=count_coeff[6] Y=n_151
Xg6865 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[7]
+ B1=n_100 B2=count_coeff[7] Y=n_150
Xg6866 AOI22xp5_ASAP7_75t_SL $PINS A1=n_117 A2=Rj_Read_Address[1] B1=n_103
+ B2=count_rj[1] Y=n_149
Xg6867 AOI22xp5_ASAP7_75t_SL $PINS A1=n_116 A2=Coefficient_Read_Address[8]
+ B1=n_100 B2=count_coeff[8] Y=n_148
Xg6868 AOI22xp5_ASAP7_75t_SL $PINS A1=n_117 A2=Rj_Read_Address[2] B1=n_103
+ B2=count_rj[2] Y=n_147
Xg6869 OR3x1_ASAP7_75t_SL $PINS A=n_83 B=n_21 C=n_144 Y=n_164
Xg6870 INVx1_ASAP7_75t_SL $PINS A=n_145 Y=n_144
Xg6871 AND2x2_ASAP7_75t_SL $PINS A=state_present[2] B=n_127 Y=n_143
Xg6872 OA211x2_ASAP7_75t_SL $PINS A1=n_51 A2=n_16 B=n_111 C=n_107 Y=n_142
Xg6873 OA21x2_ASAP7_75t_SL $PINS A1=count_data[0] A2=n_68 B=n_115 Y=n_141
Xg6874 NOR2xp33_ASAP7_75t_SL $PINS A=n_14 B=n_125 Y=n_140
Xg6875 OR2x2_ASAP7_75t_SL $PINS A=n_4 B=n_127 Y=n_146
Xg6878 NOR2xp33_ASAP7_75t_SL $PINS A=n_118 B=n_85 Y=n_145
Xg6881 OR3x1_ASAP7_75t_SL $PINS A=n_50 B=n_92 C=n_27 Y=n_138
Xg6882 OAI21xp5_ASAP7_75t_SL $PINS A1=n_47 A2=n_68 B=n_115 Y=n_137
Xg6883 OAI21xp5_ASAP7_75t_SL $PINS A1=n_56 A2=n_68 B=n_115 Y=n_136
Xg6884 AOI221xp5_ASAP7_75t_SL $PINS A1=n_76 A2=state_next[3] B1=n_31 B2=n_106
+ C=n_98 Y=n_135
Xg6885 AOI21xp5_ASAP7_75t_SL $PINS A1=n_104 A2=state_present[2] B=n_27 Y=n_134
Xg6886 NOR3xp33_ASAP7_75t_SL $PINS A=n_105 B=count_rj[2] C=n_74 Y=n_133
Xg6887 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_51 A2=state_present[1] B=count_rj[4]
+ C=n_123 Y=n_132
Xg6888 OAI22xp5_ASAP7_75t_SL $PINS A1=n_106 A2=n_32 B1=n_25 B2=n_62 Y=n_131
Xg6889 AOI221xp5_ASAP7_75t_SL $PINS A1=n_50 A2=n_28 B1=Clear B2=n_101 C=n_67
+ Y=n_130
Xg6890 OAI21xp5_ASAP7_75t_SL $PINS A1=n_82 A2=n_68 B=n_115 Y=n_139
Xg6891 INVx1_ASAP7_75t_SL $PINS A=n_128 Y=n_129
Xg6892 INVxp67_ASAP7_75t_SL $PINS A=n_125 Y=n_126
Xg6893 NOR2xp33_ASAP7_75t_R $PINS A=n_96 B=n_22 Y=n_124
Xg6894 NOR3xp33_ASAP7_75t_SL $PINS A=n_64 B=n_41 C=n_74 Y=n_123
Xg6895 NOR2xp33_ASAP7_75t_L $PINS A=state_next[1] B=n_96 Y=n_122
Xg6896 NOR2xp33_ASAP7_75t_L $PINS A=state_next[2] B=n_96 Y=n_121
Xg6897 NOR2xp33_ASAP7_75t_L $PINS A=state_next[0] B=n_96 Y=n_120
Xg6898 AND2x2_ASAP7_75t_SL $PINS A=state_present[1] B=n_105 Y=n_119
Xg6899 NOR2xp33_ASAP7_75t_SL $PINS A=n_49 B=n_104 Y=n_128
Xg6900 OR2x2_ASAP7_75t_SL $PINS A=n_6 B=n_104 Y=n_127
Xg6901 NOR2xp33_ASAP7_75t_SL $PINS A=n_8 B=n_105 Y=n_125
Xg6902 INVx1_ASAP7_75t_SL $PINS A=n_115 Y=n_114
Xg6903 AOI22xp5_ASAP7_75t_SL $PINS A1=n_71 A2=n_29 B1=Frame B2=n_35 Y=n_113
Xg6904 NOR5xp2_ASAP7_75t_SL $PINS A=n_41 B=n_38 C=count_rj[2] D=count_rj[1]
+ E=count_rj[0] Y=n_112
Xg6905 AOI221xp5_ASAP7_75t_SL $PINS A1=InReady A2=n_27 B1=n_16 B2=n_48 C=n_59
+ Y=n_111
Xg6906 NOR3xp33_ASAP7_75t_SL $PINS A=n_77 B=count_rj[1] C=n_74 Y=n_110
Xg6907 AOI21xp5_ASAP7_75t_SL $PINS A1=n_84 A2=state_present[2] B=n_27 Y=n_109
Xg6908 NAND3xp33_ASAP7_75t_SL $PINS A=n_61 B=n_16 C=Start Y=n_118
Xg6909 OR2x2_ASAP7_75t_SL $PINS A=n_101 B=n_87 Y=n_117
Xg6910 OR2x2_ASAP7_75t_SL $PINS A=n_101 B=n_88 Y=n_116
Xg6911 AOI21xp5_ASAP7_75t_SL $PINS A1=n_69 A2=n_85 B=n_101 Y=n_115
Xg6912 INVx1_ASAP7_75t_SL $PINS A=n_107 Y=n_108
Xg6913 INVx1_ASAP7_75t_SL $PINS A=n_102 Y=n_103
Xg6914 INVx1_ASAP7_75t_SL $PINS A=n_100 Y=n_99
Xg6915 NOR2xp33_ASAP7_75t_SL $PINS A=n_86 B=n_80 Y=n_98
Xg6916 NOR2xp33_ASAP7_75t_SL $PINS A=n_14 B=n_78 Y=n_97
Xg6917 NAND2xp5_ASAP7_75t_SL $PINS A=Start B=n_81 Y=n_107
Xg6918 NOR2xp33_ASAP7_75t_SL $PINS A=n_71 B=n_30 Y=n_106
Xg6919 NAND2xp5_ASAP7_75t_SL $PINS A=count_rj[1] B=n_78 Y=n_105
Xg6920 OR2x2_ASAP7_75t_SL $PINS A=n_10 B=n_84 Y=n_104
Xg6921 NAND2xp5_ASAP7_75t_SL $PINS A=n_75 B=n_54 Y=n_102
Xg6922 OR2x2_ASAP7_75t_SL $PINS A=n_2 B=n_76 Y=n_101
Xg6923 NOR2xp33_ASAP7_75t_SL $PINS A=n_49 B=n_84 Y=n_100
Xg6924 OAI21xp33_ASAP7_75t_L $PINS A1=n_24 A2=Reset_n B=n_70 Y=n_95
Xg6925 OAI21xp33_ASAP7_75t_L $PINS A1=n_23 A2=Reset_n B=n_70 Y=n_94
Xg6926 OAI21xp33_ASAP7_75t_L $PINS A1=n_25 A2=Reset_n B=n_70 Y=n_93
Xg6927 AO222x2_ASAP7_75t_SL $PINS A1=n_16 A2=input_ready B1=n_29 B2=n_34
+ C1=n_35 C2=state_present[2] Y=n_92
Xg6928 OAI21xp33_ASAP7_75t_L $PINS A1=state_next[3] A2=Reset_n B=n_70 Y=n_91
Xg6929 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=n_41 A2=n_13 B=n_33 C=n_30 Y=n_90
Xg6930 AOI21xp5_ASAP7_75t_SL $PINS A1=n_53 A2=state_present[1] B=n_79 Y=n_89
Xg6931 NOR3xp33_ASAP7_75t_SL $PINS A=n_58 B=n_13 C=n_40 Y=n_88
Xg6932 NOR3xp33_ASAP7_75t_SL $PINS A=n_54 B=n_30 C=state_present[2] Y=n_87
Xg6933 OAI21xp33_ASAP7_75t_SL $PINS A1=n_52 A2=n_36 B=n_1 Y=n_96
Xg6934 INVxp67_ASAP7_75t_SL $PINS A=n_83 Y=n_82
Xg6935 INVx1_ASAP7_75t_SL $PINS A=n_80 Y=n_81
Xg6936 INVx1_ASAP7_75t_SL $PINS A=n_77 Y=n_78
Xg6937 INVx1_ASAP7_75t_SL $PINS A=n_75 Y=n_74
Xg6938 A2O1A1Ixp33_ASAP7_75t_SL $PINS A1=n_12 A2=state_present[1] B=n_29 C=n_36
+ Y=n_73
Xg6939 NAND2xp5_ASAP7_75t_SL $PINS A=count_coeff[9] B=n_52 Y=n_72
Xg6940 NAND2xp5_ASAP7_75t_SL $PINS A=Reset_n B=n_57 Y=n_86
Xg6941 OR2x2_ASAP7_75t_SL $PINS A=n_1 B=n_57 Y=n_85
Xg6942 NAND2xp5_ASAP7_75t_SL $PINS A=n_39 B=n_58 Y=n_84
Xg6943 NAND2xp5_ASAP7_75t_SL $PINS A=count_data[3] B=n_56 Y=n_83
Xg6944 NAND2xp5_ASAP7_75t_SL $PINS A=state_present[3] B=n_50 Y=n_80
Xg6945 OR2x2_ASAP7_75t_SL $PINS A=n_51 B=n_43 Y=n_79
Xg6946 NAND2xp5_ASAP7_75t_SL $PINS A=count_rj[0] B=n_54 Y=n_77
Xg6947 NOR2xp33_ASAP7_75t_SL $PINS A=n_15 B=n_50 Y=n_76
Xg6948 NOR2xp33_ASAP7_75t_SL $PINS A=n_51 B=n_30 Y=n_75
Xg6949 INVx1_ASAP7_75t_SL $PINS A=n_69 Y=n_68
Xg6950 O2A1O1Ixp33_ASAP7_75t_SL $PINS A1=Reset_n A2=n_14 B=n_44 C=n_49 Y=n_67
Xg6951 NAND4xp25_ASAP7_75t_SL $PINS A=count_coeff[3] B=count_coeff[2]
+ C=count_coeff[1] D=count_coeff[0] Y=n_66
Xg6952 OAI21xp33_ASAP7_75t_SL $PINS A1=Reset_n A2=n_39 B=n_44 Y=n_65
Xg6953 NAND4xp25_ASAP7_75t_SL $PINS A=count_rj[2] B=count_rj[1] C=count_rj[3]
+ D=count_rj[0] Y=n_64
Xg6954 AND3x1_ASAP7_75t_SL $PINS A=n_13 B=n_29 C=input_ready Y=n_63
Xg6955 AOI22xp5_ASAP7_75t_SL $PINS A1=state_present[3] A2=n_40 B1=n_14
+ B2=state_present[2] Y=n_62
Xg6956 AOI22xp5_ASAP7_75t_SL $PINS A1=n_14 A2=n_26 B1=state_present[1] B2=n_32
+ Y=n_61
Xg6957 AND3x1_ASAP7_75t_SL $PINS A=state_present[2] B=n_39 C=input_ready Y=n_60
Xg6958 OA21x2_ASAP7_75t_SL $PINS A1=n_29 A2=n_35 B=n_28 Y=n_59
Xg6959 NAND3xp33_ASAP7_75t_SL $PINS A=n_42 B=n_45 C=Reset_n Y=n_71
Xg6960 AOI22xp33_ASAP7_75t_SL $PINS A1=n_40 A2=n_34 B1=n_1 B2=state_present[3]
+ Y=n_70
Xg6961 OAI21xp5_ASAP7_75t_SL $PINS A1=n_13 A2=n_30 B=n_15 Y=n_69
Xg6962 INVx1_ASAP7_75t_SL $PINS A=n_55 Y=n_56
Xg6963 INVxp67_ASAP7_75t_SL $PINS A=n_54 Y=n_53
Xg6964 NOR2xp33_ASAP7_75t_SL $PINS A=count_coeff[9] B=n_41 Y=n_58
Xg6965 OR2x2_ASAP7_75t_SL $PINS A=n_45 B=n_41 Y=n_57
Xg6966 NAND2xp5_ASAP7_75t_SL $PINS A=count_data[2] B=n_47 Y=n_55
Xg6967 NOR2xp33_ASAP7_75t_SL $PINS A=count_rj[4] B=n_41 Y=n_54
Xg6968 INVxp67_ASAP7_75t_SL $PINS A=n_49 Y=n_48
Xg6969 NOR2xp33_ASAP7_75t_SL $PINS A=state_present[3] B=n_40 Y=n_52
Xg6970 NAND2xp5_ASAP7_75t_SL $PINS A=n_28 B=n_13 Y=n_51
Xg6971 NOR2xp33_ASAP7_75t_SL $PINS A=state_present[2] B=n_40 Y=n_50
Xg6972 NAND2xp5_ASAP7_75t_SL $PINS A=n_28 B=state_present[2] Y=n_49
Xg6973 INVx1_ASAP7_75t_SL $PINS A=n_46 Y=n_47
Xg6974 INVxp67_ASAP7_75t_SL $PINS A=n_44 Y=n_43
Xg6975 INVx1_ASAP7_75t_SL $PINS A=n_42 Y=n_41
Xg6976 INVx1_ASAP7_75t_SL $PINS A=n_40 Y=n_39
Xg6977 NAND2xp5_ASAP7_75t_SL $PINS A=count_rj[4] B=n_18 Y=n_38
Xg6978 NAND2xp33_ASAP7_75t_SL $PINS A=Reset_n B=state_present[3] Y=n_37
Xg6979 NAND2xp5_ASAP7_75t_SL $PINS A=count_data[1] B=count_data[0] Y=n_46
Xg6980 AND2x2_ASAP7_75t_R $PINS A=allzeros_R B=allzeros_L Y=n_45
Xg6981 NAND2xp5_ASAP7_75t_SL $PINS A=state_present[0] B=state_present[1] Y=n_44
Xg6982 NOR2xp33_ASAP7_75t_SL $PINS A=n_11 B=tk Y=n_42
Xg6983 NAND2xp5_ASAP7_75t_SL $PINS A=n_14 B=n_16 Y=n_40
Xg6984 INVxp67_ASAP7_75t_SL $PINS A=n_34 Y=n_33
Xg6985 INVxp67_ASAP7_75t_SL $PINS A=n_32 Y=n_31
Xg6986 INVx1_ASAP7_75t_SL $PINS A=n_30 Y=n_29
Xg6987 INVx1_ASAP7_75t_SL $PINS A=n_28 Y=n_27
Xg6988 NAND2xp5_ASAP7_75t_SL $PINS A=state_present[3] B=n_13 Y=n_26
Xg6989 NOR2xp33_ASAP7_75t_SL $PINS A=state_present[3] B=state_present[2] Y=n_36
Xg6990 NOR2xp33_ASAP7_75t_SL $PINS A=n_16 B=state_present[1] Y=n_35
Xg6991 NOR2xp33_ASAP7_75t_SL $PINS A=Reset_n B=n_13 Y=n_34
Xg6992 NAND2xp5_ASAP7_75t_SL $PINS A=state_present[2] B=n_15 Y=n_32
Xg6993 NAND2xp5_ASAP7_75t_SL $PINS A=state_present[1] B=n_16 Y=n_30
Xg6994 NOR2xp33_ASAP7_75t_SL $PINS A=n_2 B=state_present[3] Y=n_28
Xg7003 INVx1_ASAP7_75t_SL $PINS A=state_next[2] Y=n_25
Xg7004 INVxp67_ASAP7_75t_SL $PINS A=state_next[1] Y=n_24
Xg7005 INVxp67_ASAP7_75t_SL $PINS A=state_next[0] Y=n_23
Xg7006 INVxp67_ASAP7_75t_SL $PINS A=state_next[3] Y=n_22
Xg7007 INVx1_ASAP7_75t_SL $PINS A=count_data[4] Y=n_21
Xg7008 INVx1_ASAP7_75t_SL $PINS A=count_coeff[3] Y=n_20
Xg7009 INVxp67_ASAP7_75t_SL $PINS A=count_coeff[8] Y=n_19
Xg7010 INVx1_ASAP7_75t_SL $PINS A=count_rj[3] Y=n_18
Xg7011 INVx1_ASAP7_75t_SL $PINS A=count_coeff[7] Y=n_17
Xg7012 INVx1_ASAP7_75t_SL $PINS A=state_present[0] Y=n_16
Xg7013 INVx1_ASAP7_75t_SL $PINS A=state_present[3] Y=n_15
Xg7014 INVx1_ASAP7_75t_L $PINS A=state_present[1] Y=n_14
Xg7015 INVx1_ASAP7_75t_SL $PINS A=state_present[2] Y=n_13
Xg7021 INVx1_ASAP7_75t_SL $PINS A=Frame Y=n_12
Xg7022 INVx1_ASAP7_75t_SL $PINS A=input_ready Y=n_11
Xg7023 INVx1_ASAP7_75t_SL $PINS A=count_coeff[0] Y=n_10
Xg7024 INVx1_ASAP7_75t_SL $PINS A=count_data[6] Y=n_9
Xg7025 INVx1_ASAP7_75t_SL $PINS A=count_rj[2] Y=n_8
Xg7026 INVx1_ASAP7_75t_L $PINS A=count_coeff[6] Y=n_7
Xg7027 INVx1_ASAP7_75t_SL $PINS A=count_coeff[1] Y=n_6
Xg7028 INVxp67_ASAP7_75t_SL $PINS A=count_coeff[5] Y=n_5
Xg7029 INVx1_ASAP7_75t_SL $PINS A=count_coeff[2] Y=n_4
Xg7030 INVxp67_ASAP7_75t_SL $PINS A=count_coeff[4] Y=n_3
Xg7031 INVxp67_ASAP7_75t_SL $PINS A=Start Y=n_2
Xg7032 INVx2_ASAP7_75t_SL $PINS A=Reset_n Y=n_1
.ENDS

.SUBCKT PIPO Frame Dclk Clear InputL[15] InputL[14] InputL[13] InputL[12]
+ InputL[11] InputL[10] InputL[9] InputL[8] InputL[7] InputL[6] InputL[5]
+ InputL[4] InputL[3] InputL[2] InputL[1] InputL[0] InputR[15] InputR[14]
+ InputR[13] InputR[12] InputR[11] InputR[10] InputR[9] InputR[8] InputR[7]
+ InputR[6] InputR[5] InputR[4] InputR[3] InputR[2] InputR[1] InputR[0]
+ dataL[15] dataL[14] dataL[13] dataL[12] dataL[11] dataL[10] dataL[9] dataL[8]
+ dataL[7] dataL[6] dataL[5] dataL[4] dataL[3] dataL[2] dataL[1] dataL[0]
+ dataR[15] dataR[14] dataR[13] dataR[12] dataR[11] dataR[10] dataR[9] dataR[8]
+ dataR[7] dataR[6] dataR[5] dataR[4] dataR[3] dataR[2] dataR[1] dataR[0]
+ input_ready
Xinput_ready_reg ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_68
+ D=n_67 QN=input_ready
Xg973 INVx1_ASAP7_75t_SL $PINS A=Dclk Y=n_68
Xg974 INVx1_ASAP7_75t_SL $PINS A=Frame Y=n_67
Xbitpos_reg[0] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=VSS SET=Clear CLK=n_1
+ D=n_8 QN=bitpos[0]
Xbitpos_reg[1] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=VSS SET=Clear CLK=n_1
+ D=n_43 QN=bitpos[1]
Xbitpos_reg[2] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=VSS SET=Clear CLK=n_1
+ D=n_46 QN=bitpos[2]
Xbitpos_reg[3] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=VSS SET=Clear CLK=n_1
+ D=n_48 QN=bitpos[3]
XcontinueFrame_reg ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_47 QN=continueFrame
XdataL_reg[0] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_24 QN=n_58
XdataL_reg[1] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_22 QN=n_59
XdataL_reg[2] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_19 QN=n_60
XdataL_reg[3] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_15 QN=n_61
XdataL_reg[4] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_13 QN=n_62
XdataL_reg[5] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_12 QN=n_63
XdataL_reg[6] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_11 QN=n_64
XdataL_reg[7] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_10 QN=n_65
XdataL_reg[8] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_40 QN=n_66
XdataL_reg[9] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_39 QN=dataL[9]
XdataL_reg[10] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_38 QN=dataL[10]
XdataL_reg[11] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_37 QN=dataL[11]
XdataL_reg[12] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_36 QN=dataL[12]
XdataL_reg[13] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_44 QN=dataL[13]
XdataL_reg[14] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_34 QN=dataL[14]
XdataL_reg[15] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_33 QN=dataL[15]
XdataR_reg[0] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_32 QN=n_49
XdataR_reg[1] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_31 QN=n_50
XdataR_reg[2] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_30 QN=n_51
XdataR_reg[3] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_29 QN=n_52
XdataR_reg[4] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_28 QN=n_53
XdataR_reg[5] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_35 QN=n_54
XdataR_reg[6] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_18 QN=n_55
XdataR_reg[7] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_26 QN=n_56
XdataR_reg[8] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_25 QN=n_57
XdataR_reg[9] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_23 QN=dataR[9]
XdataR_reg[10] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_21 QN=dataR[10]
XdataR_reg[11] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_20 QN=dataR[11]
XdataR_reg[12] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_27 QN=dataR[12]
XdataR_reg[13] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_17 QN=dataR[13]
XdataR_reg[14] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_16 QN=dataR[14]
XdataR_reg[15] ASYNC_DFFHx1_ASAP7_75t_SL $PINS RESET=Clear SET=VSS CLK=n_1
+ D=n_14 QN=dataR[15]
Xg1354 NOR2xp33_ASAP7_75t_SL $PINS A=n_6 B=n_45 Y=n_48
Xg1355 AOI21xp5_ASAP7_75t_SL $PINS A1=n_42 A2=continueFrame B=Frame Y=n_47
Xg1373 NOR2xp33_ASAP7_75t_SL $PINS A=n_6 B=n_41 Y=n_46
Xg1374 XOR2xp5_ASAP7_75t_SL $PINS A=bitpos[3] B=n_9 Y=n_45
Xg1391 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[13] B1=Frame B2=InputL[13]
+ Y=n_44
Xg1392 AOI211x1_ASAP7_75t_SL $PINS A1=bitpos[1] A2=bitpos[0] B=n_4 C=n_6 Y=n_43
Xg1393 NAND2xp5_ASAP7_75t_SL $PINS A=bitpos[0] B=n_7 Y=n_42
Xg1394 XOR2xp5_ASAP7_75t_SL $PINS A=bitpos[2] B=n_4 Y=n_41
Xg1395 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_66 B1=Frame B2=InputL[8] Y=n_40
Xg1396 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[9] B1=Frame B2=InputL[9]
+ Y=n_39
Xg1397 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[10] B1=Frame B2=InputL[10]
+ Y=n_38
Xg1398 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[11] B1=Frame B2=InputL[11]
+ Y=n_37
Xg1399 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[12] B1=Frame B2=InputL[12]
+ Y=n_36
Xg1400 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_54 B1=Frame B2=InputR[5] Y=n_35
Xg1401 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[14] B1=Frame B2=InputL[14]
+ Y=n_34
Xg1402 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataL[15] B1=Frame B2=InputL[15]
+ Y=n_33
Xg1403 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_49 B1=Frame B2=InputR[0] Y=n_32
Xg1404 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_50 B1=Frame B2=InputR[1] Y=n_31
Xg1405 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_51 B1=Frame B2=InputR[2] Y=n_30
Xg1406 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_52 B1=Frame B2=InputR[3] Y=n_29
Xg1407 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_53 B1=Frame B2=InputR[4] Y=n_28
Xg1409 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[12] B1=Frame B2=InputR[12]
+ Y=n_27
Xg1410 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_56 B1=Frame B2=InputR[7] Y=n_26
Xg1411 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_57 B1=Frame B2=InputR[8] Y=n_25
Xg1412 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_58 B1=Frame B2=InputL[0] Y=n_24
Xg1413 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[9] B1=Frame B2=InputR[9]
+ Y=n_23
Xg1414 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_59 B1=Frame B2=InputL[1] Y=n_22
Xg1415 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[10] B1=Frame B2=InputR[10]
+ Y=n_21
Xg1416 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[11] B1=Frame B2=InputR[11]
+ Y=n_20
Xg1417 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_60 B1=Frame B2=InputL[2] Y=n_19
Xg1418 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_55 B1=Frame B2=InputR[6] Y=n_18
Xg1419 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[13] B1=Frame B2=InputR[13]
+ Y=n_17
Xg1420 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[14] B1=Frame B2=InputR[14]
+ Y=n_16
Xg1421 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_61 B1=Frame B2=InputL[3] Y=n_15
Xg1422 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=dataR[15] B1=Frame B2=InputR[15]
+ Y=n_14
Xg1423 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_62 B1=Frame B2=InputL[4] Y=n_13
Xg1424 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_63 B1=Frame B2=InputL[5] Y=n_12
Xg1425 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_64 B1=Frame B2=InputL[6] Y=n_11
Xg1426 AOI22xp33_ASAP7_75t_SL $PINS A1=n_5 A2=n_65 B1=Frame B2=InputL[7] Y=n_10
Xg1427 NOR2xp33_ASAP7_75t_SL $PINS A=bitpos[2] B=n_3 Y=n_9
Xg1428 AND2x2_ASAP7_75t_SL $PINS A=bitpos[0] B=n_5 Y=n_8
Xg1429 NOR3xp33_ASAP7_75t_SL $PINS A=bitpos[3] B=bitpos[1] C=bitpos[2] Y=n_7
Xg1430 INVx1_ASAP7_75t_L $PINS A=n_6 Y=n_5
Xg1431 NAND2xp5_ASAP7_75t_SL $PINS A=n_2 B=continueFrame Y=n_6
Xg1432 INVx1_ASAP7_75t_SL $PINS A=n_4 Y=n_3
Xg1433 NOR2xp33_ASAP7_75t_SL $PINS A=bitpos[1] B=bitpos[0] Y=n_4
Xg1434 INVx3_ASAP7_75t_SL $PINS A=Frame Y=n_2
Xg1435 INVx1_ASAP7_75t_SL $PINS A=Dclk Y=n_1
Xdrc_bufs1438 BUFx6f_ASAP7_75t_L $PINS A=n_62 Y=dataL[4]
Xdrc_bufs1441 BUFx6f_ASAP7_75t_L $PINS A=n_58 Y=dataL[0]
Xdrc_bufs1444 BUFx6f_ASAP7_75t_L $PINS A=n_49 Y=dataR[0]
Xdrc_bufs1447 BUFx6f_ASAP7_75t_L $PINS A=n_53 Y=dataR[4]
Xdrc_bufs1450 BUFx6f_ASAP7_75t_L $PINS A=n_52 Y=dataR[3]
Xdrc_bufs1453 BUFx6f_ASAP7_75t_L $PINS A=n_60 Y=dataL[2]
Xdrc_bufs1456 BUFx6f_ASAP7_75t_L $PINS A=n_54 Y=dataR[5]
Xdrc_bufs1459 BUFx6f_ASAP7_75t_L $PINS A=n_50 Y=dataR[1]
Xdrc_bufs1462 BUFx6f_ASAP7_75t_L $PINS A=n_56 Y=dataR[7]
Xdrc_bufs1465 BUFx6f_ASAP7_75t_L $PINS A=n_59 Y=dataL[1]
Xdrc_bufs1468 BUFx6f_ASAP7_75t_L $PINS A=n_51 Y=dataR[2]
Xdrc_bufs1471 BUFx6f_ASAP7_75t_L $PINS A=n_65 Y=dataL[7]
Xdrc_bufs1474 BUFx6f_ASAP7_75t_L $PINS A=n_64 Y=dataL[6]
Xdrc_bufs1477 BUFx6f_ASAP7_75t_L $PINS A=n_55 Y=dataR[6]
Xdrc_bufs1480 BUFx6f_ASAP7_75t_L $PINS A=n_63 Y=dataL[5]
Xdrc_bufs1483 BUFx6f_ASAP7_75t_L $PINS A=n_61 Y=dataL[3]
Xdrc_bufs1486 BUFx8_ASAP7_75t_SL $PINS A=n_57 Y=dataR[8]
Xdrc_bufs1489 BUFx8_ASAP7_75t_SL $PINS A=n_66 Y=dataL[8]
.ENDS

.SUBCKT shifter shift_en load clear sclk inputdata[39] inputdata[38]
+ inputdata[37] inputdata[36] inputdata[35] inputdata[34] inputdata[33]
+ inputdata[32] inputdata[31] inputdata[30] inputdata[29] inputdata[28]
+ inputdata[27] inputdata[26] inputdata[25] inputdata[24] inputdata[23]
+ inputdata[22] inputdata[21] inputdata[20] inputdata[19] inputdata[18]
+ inputdata[17] inputdata[16] inputdata[15] inputdata[14] inputdata[13]
+ inputdata[12] inputdata[11] inputdata[10] inputdata[9] inputdata[8]
+ inputdata[7] inputdata[6] inputdata[5] inputdata[4] inputdata[3] inputdata[2]
+ inputdata[1] inputdata[0] outputdata[39] outputdata[38] outputdata[37]
+ outputdata[36] outputdata[35] outputdata[34] outputdata[33] outputdata[32]
+ outputdata[31] outputdata[30] outputdata[29] outputdata[28] outputdata[27]
+ outputdata[26] outputdata[25] outputdata[24] outputdata[23] outputdata[22]
+ outputdata[21] outputdata[20] outputdata[19] outputdata[18] outputdata[17]
+ outputdata[16] outputdata[15] outputdata[14] outputdata[13] outputdata[12]
+ outputdata[11] outputdata[10] outputdata[9] outputdata[8] outputdata[7]
+ outputdata[6] outputdata[5] outputdata[4] outputdata[3] outputdata[2]
+ outputdata[1] outputdata[0]
Xtempreg_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_21 QN=outputdata[0]
Xtempreg_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_24 QN=outputdata[1]
Xtempreg_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_20 QN=outputdata[2]
Xtempreg_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_19 QN=outputdata[3]
Xtempreg_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_18 QN=outputdata[4]
Xtempreg_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_17 QN=outputdata[5]
Xtempreg_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_16 QN=outputdata[6]
Xtempreg_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_15 QN=outputdata[7]
Xtempreg_reg[8] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_14 QN=outputdata[8]
Xtempreg_reg[9] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_13 QN=outputdata[9]
Xtempreg_reg[10] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_12 QN=outputdata[10]
Xtempreg_reg[11] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_11 QN=outputdata[11]
Xtempreg_reg[12] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_10 QN=outputdata[12]
Xtempreg_reg[13] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_9 QN=outputdata[13]
Xtempreg_reg[14] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_23 QN=outputdata[14]
Xtempreg_reg[15] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_22 QN=outputdata[15]
Xtempreg_reg[16] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_44 QN=outputdata[16]
Xtempreg_reg[17] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_43 QN=outputdata[17]
Xtempreg_reg[18] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_42 QN=outputdata[18]
Xtempreg_reg[19] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_41 QN=outputdata[19]
Xtempreg_reg[20] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_40 QN=outputdata[20]
Xtempreg_reg[21] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_39 QN=outputdata[21]
Xtempreg_reg[22] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_47 QN=outputdata[22]
Xtempreg_reg[23] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_37 QN=outputdata[23]
Xtempreg_reg[24] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_36 QN=outputdata[24]
Xtempreg_reg[25] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_35 QN=outputdata[25]
Xtempreg_reg[26] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_34 QN=outputdata[26]
Xtempreg_reg[27] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_33 QN=outputdata[27]
Xtempreg_reg[28] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_32 QN=outputdata[28]
Xtempreg_reg[29] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_31 QN=outputdata[29]
Xtempreg_reg[30] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_30 QN=outputdata[30]
Xtempreg_reg[31] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_29 QN=outputdata[31]
Xtempreg_reg[32] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_28 QN=outputdata[32]
Xtempreg_reg[33] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_27 QN=outputdata[33]
Xtempreg_reg[34] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_26 QN=outputdata[34]
Xtempreg_reg[35] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_25 QN=outputdata[35]
Xtempreg_reg[36] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_38 QN=outputdata[36]
Xtempreg_reg[37] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_46 QN=outputdata[37]
Xtempreg_reg[38] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_45 QN=outputdata[38]
Xtempreg_reg[39] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_8 QN=outputdata[39]
Xg1825 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[22] B1=outputdata[22]
+ B2=n_4 C1=n_3 C2=inputdata[23] Y=n_47
Xg1826 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[37] B1=outputdata[37]
+ B2=n_0 C1=n_3 C2=inputdata[38] Y=n_46
Xg1827 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[39] B1=outputdata[38]
+ B2=n_0 C1=n_6 C2=inputdata[38] Y=n_45
Xg1828 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[16] B1=inputdata[16]
+ B2=n_6 C1=n_3 C2=inputdata[17] Y=n_44
Xg1829 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[17] B1=inputdata[17]
+ B2=n_6 C1=n_3 C2=inputdata[18] Y=n_43
Xg1830 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[18] B1=outputdata[18]
+ B2=n_4 C1=n_3 C2=inputdata[19] Y=n_42
Xg1831 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[19] B1=inputdata[19]
+ B2=n_6 C1=n_3 C2=inputdata[20] Y=n_41
Xg1832 AOI222xp33_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[20] B1=inputdata[20]
+ B2=n_6 C1=n_3 C2=inputdata[21] Y=n_40
Xg1833 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[21] B1=inputdata[21]
+ B2=n_6 C1=n_3 C2=inputdata[22] Y=n_39
Xg1834 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[37] B1=outputdata[36]
+ B2=n_4 C1=n_6 C2=inputdata[36] Y=n_38
Xg1835 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[23] B1=outputdata[23]
+ B2=n_0 C1=n_3 C2=inputdata[24] Y=n_37
Xg1836 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[24] B1=outputdata[24]
+ B2=n_4 C1=n_3 C2=inputdata[25] Y=n_36
Xg1837 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[26] B1=outputdata[25]
+ B2=n_0 C1=n_6 C2=inputdata[25] Y=n_35
Xg1838 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[26] B1=outputdata[26]
+ B2=n_4 C1=n_3 C2=inputdata[27] Y=n_34
Xg1839 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[27] B1=outputdata[27]
+ B2=n_4 C1=n_3 C2=inputdata[28] Y=n_33
Xg1840 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[28] B1=outputdata[28]
+ B2=n_4 C1=n_3 C2=inputdata[29] Y=n_32
Xg1841 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[29] B1=outputdata[29]
+ B2=n_4 C1=n_3 C2=inputdata[30] Y=n_31
Xg1842 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[30] B1=inputdata[30]
+ B2=n_6 C1=n_3 C2=inputdata[31] Y=n_30
Xg1843 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[31] B1=outputdata[31]
+ B2=n_0 C1=n_3 C2=inputdata[32] Y=n_29
Xg1845 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[33] B1=outputdata[32]
+ B2=n_4 C1=n_6 C2=inputdata[32] Y=n_28
Xg1846 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[33] B1=outputdata[33]
+ B2=n_0 C1=n_3 C2=inputdata[34] Y=n_27
Xg1847 AOI222xp33_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[34] B1=inputdata[34]
+ B2=n_6 C1=n_3 C2=inputdata[35] Y=n_26
Xg1848 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[35] B1=outputdata[35]
+ B2=n_0 C1=n_3 C2=inputdata[36] Y=n_25
Xg1849 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[1] B1=n_3
+ B2=outputdata[2] Y=n_24
Xg1850 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[14] B1=n_3
+ B2=outputdata[15] Y=n_23
Xg1851 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[15] B1=n_3
+ B2=inputdata[16] Y=n_22
Xg1852 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[0] B1=n_3
+ B2=outputdata[1] Y=n_21
Xg1853 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[2] B1=n_3
+ B2=outputdata[3] Y=n_20
Xg1854 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[3] B1=n_3
+ B2=outputdata[4] Y=n_19
Xg1855 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[4] B1=n_3
+ B2=outputdata[5] Y=n_18
Xg1856 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[5] B1=n_3
+ B2=outputdata[6] Y=n_17
Xg1857 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[6] B1=n_3
+ B2=outputdata[7] Y=n_16
Xg1858 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[7] B1=n_3
+ B2=outputdata[8] Y=n_15
Xg1859 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[8] B1=n_3
+ B2=outputdata[9] Y=n_14
Xg1860 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[9] B1=n_3
+ B2=outputdata[10] Y=n_13
Xg1861 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[10] B1=n_3
+ B2=outputdata[11] Y=n_12
Xg1862 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[11] B1=n_3
+ B2=outputdata[12] Y=n_11
Xg1863 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[12] B1=n_3
+ B2=outputdata[13] Y=n_10
Xg1864 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[13] B1=n_3
+ B2=outputdata[14] Y=n_9
Xg1865 AOI22xp5_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[39] B1=load
+ B2=inputdata[39] Y=n_8
Xg1866 NAND2xp5_ASAP7_75t_SL $PINS A=n_5 B=n_1 Y=n_7
Xg1867 INVx1_ASAP7_75t_SL $PINS A=n_6 Y=n_5
Xg1868 AND2x2_ASAP7_75t_SL $PINS A=load B=n_2 Y=n_6
Xg1870 NOR2xp33_ASAP7_75t_SL $PINS A=clear B=load Y=n_4
Xg1871 AND2x2_ASAP7_75t_SL $PINS A=shift_en B=load Y=n_3
Xg1889 INVxp67_ASAP7_75t_SL $PINS A=shift_en Y=n_2
Xdrc_bufs1895 INVx1_ASAP7_75t_SL $PINS A=n_1 Y=n_0
Xdrc_bufs1896 INVxp67_ASAP7_75t_SL $PINS A=n_4 Y=n_1
.ENDS

.SUBCKT shifter_1 shift_en load clear sclk inputdata[39] inputdata[38]
+ inputdata[37] inputdata[36] inputdata[35] inputdata[34] inputdata[33]
+ inputdata[32] inputdata[31] inputdata[30] inputdata[29] inputdata[28]
+ inputdata[27] inputdata[26] inputdata[25] inputdata[24] inputdata[23]
+ inputdata[22] inputdata[21] inputdata[20] inputdata[19] inputdata[18]
+ inputdata[17] inputdata[16] inputdata[15] inputdata[14] inputdata[13]
+ inputdata[12] inputdata[11] inputdata[10] inputdata[9] inputdata[8]
+ inputdata[7] inputdata[6] inputdata[5] inputdata[4] inputdata[3] inputdata[2]
+ inputdata[1] inputdata[0] outputdata[39] outputdata[38] outputdata[37]
+ outputdata[36] outputdata[35] outputdata[34] outputdata[33] outputdata[32]
+ outputdata[31] outputdata[30] outputdata[29] outputdata[28] outputdata[27]
+ outputdata[26] outputdata[25] outputdata[24] outputdata[23] outputdata[22]
+ outputdata[21] outputdata[20] outputdata[19] outputdata[18] outputdata[17]
+ outputdata[16] outputdata[15] outputdata[14] outputdata[13] outputdata[12]
+ outputdata[11] outputdata[10] outputdata[9] outputdata[8] outputdata[7]
+ outputdata[6] outputdata[5] outputdata[4] outputdata[3] outputdata[2]
+ outputdata[1] outputdata[0]
Xtempreg_reg[0] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_21 QN=outputdata[0]
Xtempreg_reg[1] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_24 QN=outputdata[1]
Xtempreg_reg[2] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_20 QN=outputdata[2]
Xtempreg_reg[3] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_19 QN=outputdata[3]
Xtempreg_reg[4] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_18 QN=outputdata[4]
Xtempreg_reg[5] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_17 QN=outputdata[5]
Xtempreg_reg[6] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_16 QN=outputdata[6]
Xtempreg_reg[7] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_15 QN=outputdata[7]
Xtempreg_reg[8] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_14 QN=outputdata[8]
Xtempreg_reg[9] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_13 QN=outputdata[9]
Xtempreg_reg[10] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_12 QN=outputdata[10]
Xtempreg_reg[11] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_11 QN=outputdata[11]
Xtempreg_reg[12] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_10 QN=outputdata[12]
Xtempreg_reg[13] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_9 QN=outputdata[13]
Xtempreg_reg[14] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_23 QN=outputdata[14]
Xtempreg_reg[15] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_22 QN=outputdata[15]
Xtempreg_reg[16] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_44 QN=outputdata[16]
Xtempreg_reg[17] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_43 QN=outputdata[17]
Xtempreg_reg[18] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_42 QN=outputdata[18]
Xtempreg_reg[19] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_41 QN=outputdata[19]
Xtempreg_reg[20] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_40 QN=outputdata[20]
Xtempreg_reg[21] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_39 QN=outputdata[21]
Xtempreg_reg[22] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_47 QN=outputdata[22]
Xtempreg_reg[23] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_37 QN=outputdata[23]
Xtempreg_reg[24] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_36 QN=outputdata[24]
Xtempreg_reg[25] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_35 QN=outputdata[25]
Xtempreg_reg[26] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_34 QN=outputdata[26]
Xtempreg_reg[27] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_33 QN=outputdata[27]
Xtempreg_reg[28] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_32 QN=outputdata[28]
Xtempreg_reg[29] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_31 QN=outputdata[29]
Xtempreg_reg[30] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_30 QN=outputdata[30]
Xtempreg_reg[31] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_29 QN=outputdata[31]
Xtempreg_reg[32] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_28 QN=outputdata[32]
Xtempreg_reg[33] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_27 QN=outputdata[33]
Xtempreg_reg[34] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_26 QN=outputdata[34]
Xtempreg_reg[35] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_25 QN=outputdata[35]
Xtempreg_reg[36] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_38 QN=outputdata[36]
Xtempreg_reg[37] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_46 QN=outputdata[37]
Xtempreg_reg[38] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_45 QN=outputdata[38]
Xtempreg_reg[39] DFFLQNx1_ASAP7_75t_SL $PINS CLK=sclk D=n_8 QN=outputdata[39]
Xg1825 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[22] B1=outputdata[22]
+ B2=n_4 C1=n_3 C2=inputdata[23] Y=n_47
Xg1826 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[37] B1=outputdata[37]
+ B2=n_0 C1=n_3 C2=inputdata[38] Y=n_46
Xg1827 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[39] B1=outputdata[38]
+ B2=n_0 C1=n_6 C2=inputdata[38] Y=n_45
Xg1828 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[16] B1=inputdata[16]
+ B2=n_6 C1=n_3 C2=inputdata[17] Y=n_44
Xg1829 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[17] B1=inputdata[17]
+ B2=n_6 C1=n_3 C2=inputdata[18] Y=n_43
Xg1830 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[18] B1=outputdata[18]
+ B2=n_4 C1=n_3 C2=inputdata[19] Y=n_42
Xg1831 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[19] B1=inputdata[19]
+ B2=n_6 C1=n_3 C2=inputdata[20] Y=n_41
Xg1832 AOI222xp33_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[20] B1=inputdata[20]
+ B2=n_6 C1=n_3 C2=inputdata[21] Y=n_40
Xg1833 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[21] B1=inputdata[21]
+ B2=n_6 C1=n_3 C2=inputdata[22] Y=n_39
Xg1834 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[37] B1=outputdata[36]
+ B2=n_4 C1=n_6 C2=inputdata[36] Y=n_38
Xg1835 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[23] B1=outputdata[23]
+ B2=n_0 C1=n_3 C2=inputdata[24] Y=n_37
Xg1836 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[24] B1=outputdata[24]
+ B2=n_4 C1=n_3 C2=inputdata[25] Y=n_36
Xg1837 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[26] B1=outputdata[25]
+ B2=n_0 C1=n_6 C2=inputdata[25] Y=n_35
Xg1838 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[26] B1=outputdata[26]
+ B2=n_4 C1=n_3 C2=inputdata[27] Y=n_34
Xg1839 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[27] B1=outputdata[27]
+ B2=n_4 C1=n_3 C2=inputdata[28] Y=n_33
Xg1840 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[28] B1=outputdata[28]
+ B2=n_4 C1=n_3 C2=inputdata[29] Y=n_32
Xg1841 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[29] B1=outputdata[29]
+ B2=n_4 C1=n_3 C2=inputdata[30] Y=n_31
Xg1842 AOI222xp33_ASAP7_75t_SL $PINS A1=n_0 A2=outputdata[30] B1=inputdata[30]
+ B2=n_6 C1=n_3 C2=inputdata[31] Y=n_30
Xg1843 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[31] B1=outputdata[31]
+ B2=n_0 C1=n_3 C2=inputdata[32] Y=n_29
Xg1845 AOI222xp33_ASAP7_75t_SL $PINS A1=n_3 A2=inputdata[33] B1=outputdata[32]
+ B2=n_4 C1=n_6 C2=inputdata[32] Y=n_28
Xg1846 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[33] B1=outputdata[33]
+ B2=n_0 C1=n_3 C2=inputdata[34] Y=n_27
Xg1847 AOI222xp33_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[34] B1=inputdata[34]
+ B2=n_6 C1=n_3 C2=inputdata[35] Y=n_26
Xg1848 AOI222xp33_ASAP7_75t_SL $PINS A1=n_6 A2=inputdata[35] B1=outputdata[35]
+ B2=n_0 C1=n_3 C2=inputdata[36] Y=n_25
Xg1849 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[1] B1=n_3
+ B2=outputdata[2] Y=n_24
Xg1850 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[14] B1=n_3
+ B2=outputdata[15] Y=n_23
Xg1851 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[15] B1=n_3
+ B2=inputdata[16] Y=n_22
Xg1852 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[0] B1=n_3
+ B2=outputdata[1] Y=n_21
Xg1853 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[2] B1=n_3
+ B2=outputdata[3] Y=n_20
Xg1854 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[3] B1=n_3
+ B2=outputdata[4] Y=n_19
Xg1855 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[4] B1=n_3
+ B2=outputdata[5] Y=n_18
Xg1856 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[5] B1=n_3
+ B2=outputdata[6] Y=n_17
Xg1857 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[6] B1=n_3
+ B2=outputdata[7] Y=n_16
Xg1858 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[7] B1=n_3
+ B2=outputdata[8] Y=n_15
Xg1859 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[8] B1=n_3
+ B2=outputdata[9] Y=n_14
Xg1860 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[9] B1=n_3
+ B2=outputdata[10] Y=n_13
Xg1861 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[10] B1=n_3
+ B2=outputdata[11] Y=n_12
Xg1862 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[11] B1=n_3
+ B2=outputdata[12] Y=n_11
Xg1863 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[12] B1=n_3
+ B2=outputdata[13] Y=n_10
Xg1864 AOI22xp5_ASAP7_75t_SL $PINS A1=n_7 A2=outputdata[13] B1=n_3
+ B2=outputdata[14] Y=n_9
Xg1865 AOI22xp5_ASAP7_75t_SL $PINS A1=n_4 A2=outputdata[39] B1=load
+ B2=inputdata[39] Y=n_8
Xg1866 NAND2xp5_ASAP7_75t_SL $PINS A=n_5 B=n_1 Y=n_7
Xg1867 INVx1_ASAP7_75t_SL $PINS A=n_6 Y=n_5
Xg1868 AND2x2_ASAP7_75t_SL $PINS A=load B=n_2 Y=n_6
Xg1870 NOR2xp33_ASAP7_75t_SL $PINS A=clear B=load Y=n_4
Xg1871 AND2x2_ASAP7_75t_SL $PINS A=shift_en B=load Y=n_3
Xg1889 INVxp67_ASAP7_75t_SL $PINS A=shift_en Y=n_2
Xdrc_bufs1895 INVx1_ASAP7_75t_SL $PINS A=n_1 Y=n_0
Xdrc_bufs1896 INVxp67_ASAP7_75t_SL $PINS A=n_4 Y=n_1
.ENDS

.SUBCKT MSDAP Dclk Sclk Reset_n Frame Start InputL[15] InputL[14] InputL[13]
+ InputL[12] InputL[11] InputL[10] InputL[9] InputL[8] InputL[7] InputL[6]
+ InputL[5] InputL[4] InputL[3] InputL[2] InputL[1] InputL[0] InputR[15]
+ InputR[14] InputR[13] InputR[12] InputR[11] InputR[10] InputR[9] InputR[8]
+ InputR[7] InputR[6] InputR[5] InputR[4] InputR[3] InputR[2] InputR[1]
+ InputR[0] InReady OutReady OutputL OutputR
XCo_mem_L CO_MEM $PINS write_enable=coeff_enable read_enable=rjL_enable
+ Sclk=Sclk Frame=Frame Write_Address[8]=coeffwrite[8]
+ Write_Address[7]=coeffwrite[7] Write_Address[6]=coeffwrite[6]
+ Write_Address[5]=coeffwrite[5] Write_Address[4]=coeffwrite[4]
+ Write_Address[3]=coeffwrite[3] Write_Address[2]=coeffwrite[2]
+ Write_Address[1]=coeffwrite[1] Write_Address[0]=coeffwrite[0]
+ Read_Address[8]=coeffL_addr[8] Read_Address[7]=coeffL_addr[7]
+ Read_Address[6]=coeffL_addr[6] Read_Address[5]=coeffL_addr[5]
+ Read_Address[4]=coeffL_addr[4] Read_Address[3]=coeffL_addr[3]
+ Read_Address[2]=coeffL_addr[2] Read_Address[1]=coeffL_addr[1]
+ Read_Address[0]=coeffL_addr[0] data_in[15]=VSS data_in[14]=VSS data_in[13]=VSS
+ data_in[12]=VSS data_in[11]=VSS data_in[10]=VSS data_in[9]=VSS
+ data_in[8]=dataL[8] data_in[7]=dataL[7] data_in[6]=dataL[6] data_in[5]=dataL[5]
+ data_in[4]=dataL[4] data_in[3]=dataL[3] data_in[2]=dataL[2] data_in[1]=dataL[1]
+ data_in[0]=dataL[0] Coeff[15]=coeffdataL[15] Coeff[14]=coeffdataL[14]
+ Coeff[13]=coeffdataL[13] Coeff[12]=coeffdataL[12] Coeff[11]=coeffdataL[11]
+ Coeff[10]=coeffdataL[10] Coeff[9]=coeffdataL[9] Coeff[8]=coeffdataL[8]
+ Coeff[7]=coeffdataL[7] Coeff[6]=coeffdataL[6] Coeff[5]=coeffdataL[5]
+ Coeff[4]=coeffdataL[4] Coeff[3]=coeffdataL[3] Coeff[2]=coeffdataL[2]
+ Coeff[1]=coeffdataL[1] Coeff[0]=coeffdataL[0]
XCo_mem_R CO_MEM_1 $PINS write_enable=coeff_enable read_enable=rjR_enable
+ Sclk=Sclk Frame=Frame Write_Address[8]=coeffwrite[8]
+ Write_Address[7]=coeffwrite[7] Write_Address[6]=coeffwrite[6]
+ Write_Address[5]=coeffwrite[5] Write_Address[4]=coeffwrite[4]
+ Write_Address[3]=coeffwrite[3] Write_Address[2]=coeffwrite[2]
+ Write_Address[1]=coeffwrite[1] Write_Address[0]=coeffwrite[0]
+ Read_Address[8]=coeffR_addr[8] Read_Address[7]=coeffR_addr[7]
+ Read_Address[6]=coeffR_addr[6] Read_Address[5]=coeffR_addr[5]
+ Read_Address[4]=coeffR_addr[4] Read_Address[3]=coeffR_addr[3]
+ Read_Address[2]=coeffR_addr[2] Read_Address[1]=coeffR_addr[1]
+ Read_Address[0]=coeffR_addr[0] data_in[15]=VSS data_in[14]=VSS data_in[13]=VSS
+ data_in[12]=VSS data_in[11]=VSS data_in[10]=VSS data_in[9]=VSS
+ data_in[8]=dataR[8] data_in[7]=dataR[7] data_in[6]=dataR[6] data_in[5]=dataR[5]
+ data_in[4]=dataR[4] data_in[3]=dataR[3] data_in[2]=dataR[2] data_in[1]=dataR[1]
+ data_in[0]=dataR[0] Coeff[15]=coeffdataR[15] Coeff[14]=coeffdataR[14]
+ Coeff[13]=coeffdataR[13] Coeff[12]=coeffdataR[12] Coeff[11]=coeffdataR[11]
+ Coeff[10]=coeffdataR[10] Coeff[9]=coeffdataR[9] Coeff[8]=coeffdataR[8]
+ Coeff[7]=coeffdataR[7] Coeff[6]=coeffdataR[6] Coeff[5]=coeffdataR[5]
+ Coeff[4]=coeffdataR[4] Coeff[3]=coeffdataR[3] Coeff[2]=coeffdataR[2]
+ Coeff[1]=coeffdataR[1] Coeff[0]=coeffdataR[0]
XData_mem_L DATA_MEM $PINS write_enable=data_enable read_enable=inputL_enable
+ Sclk=Sclk Frame=Frame input_ready=input_ready Write_Address[7]=datawrite[7]
+ Write_Address[6]=datawrite[6] Write_Address[5]=datawrite[5]
+ Write_Address[4]=datawrite[4] Write_Address[3]=datawrite[3]
+ Write_Address[2]=datawrite[2] Write_Address[1]=datawrite[1]
+ Write_Address[0]=datawrite[0] Read_Address[7]=inputL_addr[7]
+ Read_Address[6]=inputL_addr[6] Read_Address[5]=inputL_addr[5]
+ Read_Address[4]=inputL_addr[4] Read_Address[3]=inputL_addr[3]
+ Read_Address[2]=inputL_addr[2] Read_Address[1]=inputL_addr[1]
+ Read_Address[0]=inputL_addr[0] data_in[15]=dataL[15] data_in[14]=dataL[14]
+ data_in[13]=dataL[13] data_in[12]=dataL[12] data_in[11]=dataL[11]
+ data_in[10]=dataL[10] data_in[9]=dataL[9] data_in[8]=dataL[8]
+ data_in[7]=dataL[7] data_in[6]=dataL[6] data_in[5]=dataL[5] data_in[4]=dataL[4]
+ data_in[3]=dataL[3] data_in[2]=dataL[2] data_in[1]=dataL[1] data_in[0]=dataL[0]
+ data_stored[15]=addL_input[39] data_stored[14]=indataL[14]
+ data_stored[13]=indataL[13] data_stored[12]=indataL[12]
+ data_stored[11]=indataL[11] data_stored[10]=indataL[10]
+ data_stored[9]=indataL[9] data_stored[8]=indataL[8] data_stored[7]=indataL[7]
+ data_stored[6]=indataL[6] data_stored[5]=indataL[5] data_stored[4]=indataL[4]
+ data_stored[3]=indataL[3] data_stored[2]=indataL[2] data_stored[1]=indataL[1]
+ data_stored[0]=indataL[0] allzeros=flag_zeroL
XData_mem_R DATA_MEM_1 $PINS write_enable=data_enable read_enable=inputR_enable
+ Sclk=Sclk Frame=Frame input_ready=input_ready Write_Address[7]=datawrite[7]
+ Write_Address[6]=datawrite[6] Write_Address[5]=datawrite[5]
+ Write_Address[4]=datawrite[4] Write_Address[3]=datawrite[3]
+ Write_Address[2]=datawrite[2] Write_Address[1]=datawrite[1]
+ Write_Address[0]=datawrite[0] Read_Address[7]=inputR_addr[7]
+ Read_Address[6]=inputR_addr[6] Read_Address[5]=inputR_addr[5]
+ Read_Address[4]=inputR_addr[4] Read_Address[3]=inputR_addr[3]
+ Read_Address[2]=inputR_addr[2] Read_Address[1]=inputR_addr[1]
+ Read_Address[0]=inputR_addr[0] data_in[15]=dataR[15] data_in[14]=dataR[14]
+ data_in[13]=dataR[13] data_in[12]=dataR[12] data_in[11]=dataR[11]
+ data_in[10]=dataR[10] data_in[9]=dataR[9] data_in[8]=dataR[8]
+ data_in[7]=dataR[7] data_in[6]=dataR[6] data_in[5]=dataR[5] data_in[4]=dataR[4]
+ data_in[3]=dataR[3] data_in[2]=dataR[2] data_in[1]=dataR[1] data_in[0]=dataR[0]
+ data_stored[15]=addR_input[39] data_stored[14]=indataR[14]
+ data_stored[13]=indataR[13] data_stored[12]=indataR[12]
+ data_stored[11]=indataR[11] data_stored[10]=indataR[10]
+ data_stored[9]=indataR[9] data_stored[8]=indataR[8] data_stored[7]=indataR[7]
+ data_stored[6]=indataR[6] data_stored[5]=indataR[5] data_stored[4]=indataR[4]
+ data_stored[3]=indataR[3] data_stored[2]=indataR[2] data_stored[1]=indataR[1]
+ data_stored[0]=indataR[0] allzeros=flag_zeroR
XPISOL PISO $PINS Sclk=Sclk Clear=Clear Frame=Frame enable_PISO=en_PISO_L
+ InputParallel[39]=Shift_done_L[39] InputParallel[38]=Shift_done_L[38]
+ InputParallel[37]=Shift_done_L[37] InputParallel[36]=Shift_done_L[36]
+ InputParallel[35]=Shift_done_L[35] InputParallel[34]=Shift_done_L[34]
+ InputParallel[33]=Shift_done_L[33] InputParallel[32]=Shift_done_L[32]
+ InputParallel[31]=Shift_done_L[31] InputParallel[30]=Shift_done_L[30]
+ InputParallel[29]=Shift_done_L[29] InputParallel[28]=Shift_done_L[28]
+ InputParallel[27]=Shift_done_L[27] InputParallel[26]=Shift_done_L[26]
+ InputParallel[25]=Shift_done_L[25] InputParallel[24]=Shift_done_L[24]
+ InputParallel[23]=Shift_done_L[23] InputParallel[22]=Shift_done_L[22]
+ InputParallel[21]=Shift_done_L[21] InputParallel[20]=Shift_done_L[20]
+ InputParallel[19]=Shift_done_L[19] InputParallel[18]=Shift_done_L[18]
+ InputParallel[17]=Shift_done_L[17] InputParallel[16]=Shift_done_L[16]
+ InputParallel[15]=Shift_done_L[15] InputParallel[14]=Shift_done_L[14]
+ InputParallel[13]=Shift_done_L[13] InputParallel[12]=Shift_done_L[12]
+ InputParallel[11]=Shift_done_L[11] InputParallel[10]=Shift_done_L[10]
+ InputParallel[9]=Shift_done_L[9] InputParallel[8]=Shift_done_L[8]
+ InputParallel[7]=Shift_done_L[7] InputParallel[6]=Shift_done_L[6]
+ InputParallel[5]=Shift_done_L[5] InputParallel[4]=Shift_done_L[4]
+ InputParallel[3]=Shift_done_L[3] InputParallel[2]=Shift_done_L[2]
+ InputParallel[1]=Shift_done_L[1] InputParallel[0]=Shift_done_L[0]
+ OutputSerial=OutputL OutReady=OutReadyL
XPISOR PISO_1 $PINS Sclk=Sclk Clear=Clear Frame=Frame enable_PISO=en_PISO_R
+ InputParallel[39]=Shift_done_R[39] InputParallel[38]=Shift_done_R[38]
+ InputParallel[37]=Shift_done_R[37] InputParallel[36]=Shift_done_R[36]
+ InputParallel[35]=Shift_done_R[35] InputParallel[34]=Shift_done_R[34]
+ InputParallel[33]=Shift_done_R[33] InputParallel[32]=Shift_done_R[32]
+ InputParallel[31]=Shift_done_R[31] InputParallel[30]=Shift_done_R[30]
+ InputParallel[29]=Shift_done_R[29] InputParallel[28]=Shift_done_R[28]
+ InputParallel[27]=Shift_done_R[27] InputParallel[26]=Shift_done_R[26]
+ InputParallel[25]=Shift_done_R[25] InputParallel[24]=Shift_done_R[24]
+ InputParallel[23]=Shift_done_R[23] InputParallel[22]=Shift_done_R[22]
+ InputParallel[21]=Shift_done_R[21] InputParallel[20]=Shift_done_R[20]
+ InputParallel[19]=Shift_done_R[19] InputParallel[18]=Shift_done_R[18]
+ InputParallel[17]=Shift_done_R[17] InputParallel[16]=Shift_done_R[16]
+ InputParallel[15]=Shift_done_R[15] InputParallel[14]=Shift_done_R[14]
+ InputParallel[13]=Shift_done_R[13] InputParallel[12]=Shift_done_R[12]
+ InputParallel[11]=Shift_done_R[11] InputParallel[10]=Shift_done_R[10]
+ InputParallel[9]=Shift_done_R[9] InputParallel[8]=Shift_done_R[8]
+ InputParallel[7]=Shift_done_R[7] InputParallel[6]=Shift_done_R[6]
+ InputParallel[5]=Shift_done_R[5] InputParallel[4]=Shift_done_R[4]
+ InputParallel[3]=Shift_done_R[3] InputParallel[2]=Shift_done_R[2]
+ InputParallel[1]=Shift_done_R[1] InputParallel[0]=Shift_done_R[0]
+ OutputSerial=OutputR OutReady=OutReadyR
XR_mem_L R_MEM $PINS write_enable=rj_enable read_enable=rjL_enable Sclk=Sclk
+ Frame=Frame Write_Address[3]=rjwrite[3] Write_Address[2]=rjwrite[2]
+ Write_Address[1]=rjwrite[1] Write_Address[0]=rjwrite[0]
+ Read_Address[3]=rjL_addr[3] Read_Address[2]=rjL_addr[2]
+ Read_Address[1]=rjL_addr[1] Read_Address[0]=rjL_addr[0] data_in[15]=VSS
+ data_in[14]=VSS data_in[13]=VSS data_in[12]=VSS data_in[11]=VSS data_in[10]=VSS
+ data_in[9]=VSS data_in[8]=VSS data_in[7]=dataL[7] data_in[6]=dataL[6]
+ data_in[5]=dataL[5] data_in[4]=dataL[4] data_in[3]=dataL[3] data_in[2]=dataL[2]
+ data_in[1]=dataL[1] data_in[0]=dataL[0] Rj[15]=UNCONNECTED6 Rj[14]=UNCONNECTED5
+ Rj[13]=UNCONNECTED4 Rj[12]=UNCONNECTED3 Rj[11]=UNCONNECTED2 Rj[10]=UNCONNECTED1
+ Rj[9]=UNCONNECTED0 Rj[8]=UNCONNECTED Rj[7]=rjdataL[7] Rj[6]=rjdataL[6]
+ Rj[5]=rjdataL[5] Rj[4]=rjdataL[4] Rj[3]=rjdataL[3] Rj[2]=rjdataL[2]
+ Rj[1]=rjdataL[1] Rj[0]=rjdataL[0]
XR_mem_R R_MEM_1 $PINS write_enable=rj_enable read_enable=rjR_enable Sclk=Sclk
+ Frame=Frame Write_Address[3]=rjwrite[3] Write_Address[2]=rjwrite[2]
+ Write_Address[1]=rjwrite[1] Write_Address[0]=rjwrite[0]
+ Read_Address[3]=rjR_addr[3] Read_Address[2]=rjR_addr[2]
+ Read_Address[1]=rjR_addr[1] Read_Address[0]=rjR_addr[0] data_in[15]=VSS
+ data_in[14]=VSS data_in[13]=VSS data_in[12]=VSS data_in[11]=VSS data_in[10]=VSS
+ data_in[9]=VSS data_in[8]=VSS data_in[7]=dataR[7] data_in[6]=dataR[6]
+ data_in[5]=dataR[5] data_in[4]=dataR[4] data_in[3]=dataR[3] data_in[2]=dataR[2]
+ data_in[1]=dataR[1] data_in[0]=dataR[0] Rj[15]=UNCONNECTED14
+ Rj[14]=UNCONNECTED13 Rj[13]=UNCONNECTED12 Rj[12]=UNCONNECTED11
+ Rj[11]=UNCONNECTED10 Rj[10]=UNCONNECTED9 Rj[9]=UNCONNECTED8 Rj[8]=UNCONNECTED7
+ Rj[7]=rjdataR[7] Rj[6]=rjdataR[6] Rj[5]=rjdataR[5] Rj[4]=rjdataR[4]
+ Rj[3]=rjdataR[3] Rj[2]=rjdataR[2] Rj[1]=rjdataR[1] Rj[0]=rjdataR[0]
XaddL adder $PINS input1[39]=VSS input1[38]=VSS input1[37]=VSS input1[36]=VSS
+ input1[35]=VSS input1[34]=VSS input1[33]=VSS input1[32]=VSS
+ input1[31]=addL_input[39] input1[30]=indataL[14] input1[29]=indataL[13]
+ input1[28]=indataL[12] input1[27]=indataL[11] input1[26]=indataL[10]
+ input1[25]=indataL[9] input1[24]=indataL[8] input1[23]=indataL[7]
+ input1[22]=indataL[6] input1[21]=indataL[5] input1[20]=indataL[4]
+ input1[19]=indataL[3] input1[18]=indataL[2] input1[17]=indataL[1]
+ input1[16]=indataL[0] input1[15]=VSS input1[14]=VSS input1[13]=VSS
+ input1[12]=VSS input1[11]=VSS input1[10]=VSS input1[9]=VSS input1[8]=VSS
+ input1[7]=VSS input1[6]=VSS input1[5]=VSS input1[4]=VSS input1[3]=VSS
+ input1[2]=VSS input1[1]=VSS input1[0]=VSS input2[39]=Shift_done_L[39]
+ input2[38]=Shift_done_L[38] input2[37]=Shift_done_L[37]
+ input2[36]=Shift_done_L[36] input2[35]=Shift_done_L[35]
+ input2[34]=Shift_done_L[34] input2[33]=Shift_done_L[33]
+ input2[32]=Shift_done_L[32] input2[31]=Shift_done_L[31]
+ input2[30]=Shift_done_L[30] input2[29]=Shift_done_L[29]
+ input2[28]=Shift_done_L[28] input2[27]=Shift_done_L[27]
+ input2[26]=Shift_done_L[26] input2[25]=Shift_done_L[25]
+ input2[24]=Shift_done_L[24] input2[23]=Shift_done_L[23]
+ input2[22]=Shift_done_L[22] input2[21]=Shift_done_L[21]
+ input2[20]=Shift_done_L[20] input2[19]=Shift_done_L[19]
+ input2[18]=Shift_done_L[18] input2[17]=Shift_done_L[17]
+ input2[16]=Shift_done_L[16] input2[15]=VSS input2[14]=VSS input2[13]=VSS
+ input2[12]=VSS input2[11]=VSS input2[10]=VSS input2[9]=VSS input2[8]=VSS
+ input2[7]=VSS input2[6]=VSS input2[5]=VSS input2[4]=VSS input2[3]=VSS
+ input2[2]=VSS input2[1]=VSS input2[0]=VSS op=addsubL out[39]=sum_L[39]
+ out[38]=sum_L[38] out[37]=sum_L[37] out[36]=sum_L[36] out[35]=sum_L[35]
+ out[34]=sum_L[34] out[33]=sum_L[33] out[32]=sum_L[32] out[31]=sum_L[31]
+ out[30]=sum_L[30] out[29]=sum_L[29] out[28]=sum_L[28] out[27]=sum_L[27]
+ out[26]=sum_L[26] out[25]=sum_L[25] out[24]=sum_L[24] out[23]=sum_L[23]
+ out[22]=sum_L[22] out[21]=sum_L[21] out[20]=sum_L[20] out[19]=sum_L[19]
+ out[18]=sum_L[18] out[17]=sum_L[17] out[16]=sum_L[16] out[15]=UNCONNECTED30
+ out[14]=UNCONNECTED29 out[13]=UNCONNECTED28 out[12]=UNCONNECTED27
+ out[11]=UNCONNECTED26 out[10]=UNCONNECTED25 out[9]=UNCONNECTED24
+ out[8]=UNCONNECTED23 out[7]=UNCONNECTED22 out[6]=UNCONNECTED21
+ out[5]=UNCONNECTED20 out[4]=UNCONNECTED19 out[3]=UNCONNECTED18
+ out[2]=UNCONNECTED17 out[1]=UNCONNECTED16 out[0]=UNCONNECTED15
XaddR adder_1 $PINS input1[39]=VSS input1[38]=VSS input1[37]=VSS input1[36]=VSS
+ input1[35]=VSS input1[34]=VSS input1[33]=VSS input1[32]=VSS
+ input1[31]=addR_input[39] input1[30]=indataR[14] input1[29]=indataR[13]
+ input1[28]=indataR[12] input1[27]=indataR[11] input1[26]=indataR[10]
+ input1[25]=indataR[9] input1[24]=indataR[8] input1[23]=indataR[7]
+ input1[22]=indataR[6] input1[21]=indataR[5] input1[20]=indataR[4]
+ input1[19]=indataR[3] input1[18]=indataR[2] input1[17]=indataR[1]
+ input1[16]=indataR[0] input1[15]=VSS input1[14]=VSS input1[13]=VSS
+ input1[12]=VSS input1[11]=VSS input1[10]=VSS input1[9]=VSS input1[8]=VSS
+ input1[7]=VSS input1[6]=VSS input1[5]=VSS input1[4]=VSS input1[3]=VSS
+ input1[2]=VSS input1[1]=VSS input1[0]=VSS input2[39]=Shift_done_R[39]
+ input2[38]=Shift_done_R[38] input2[37]=Shift_done_R[37]
+ input2[36]=Shift_done_R[36] input2[35]=Shift_done_R[35]
+ input2[34]=Shift_done_R[34] input2[33]=Shift_done_R[33]
+ input2[32]=Shift_done_R[32] input2[31]=Shift_done_R[31]
+ input2[30]=Shift_done_R[30] input2[29]=Shift_done_R[29]
+ input2[28]=Shift_done_R[28] input2[27]=Shift_done_R[27]
+ input2[26]=Shift_done_R[26] input2[25]=Shift_done_R[25]
+ input2[24]=Shift_done_R[24] input2[23]=Shift_done_R[23]
+ input2[22]=Shift_done_R[22] input2[21]=Shift_done_R[21]
+ input2[20]=Shift_done_R[20] input2[19]=Shift_done_R[19]
+ input2[18]=Shift_done_R[18] input2[17]=Shift_done_R[17]
+ input2[16]=Shift_done_R[16] input2[15]=VSS input2[14]=VSS input2[13]=VSS
+ input2[12]=VSS input2[11]=VSS input2[10]=VSS input2[9]=VSS input2[8]=VSS
+ input2[7]=VSS input2[6]=VSS input2[5]=VSS input2[4]=VSS input2[3]=VSS
+ input2[2]=VSS input2[1]=VSS input2[0]=VSS op=addsubR out[39]=sum_R[39]
+ out[38]=sum_R[38] out[37]=sum_R[37] out[36]=sum_R[36] out[35]=sum_R[35]
+ out[34]=sum_R[34] out[33]=sum_R[33] out[32]=sum_R[32] out[31]=sum_R[31]
+ out[30]=sum_R[30] out[29]=sum_R[29] out[28]=sum_R[28] out[27]=sum_R[27]
+ out[26]=sum_R[26] out[25]=sum_R[25] out[24]=sum_R[24] out[23]=sum_R[23]
+ out[22]=sum_R[22] out[21]=sum_R[21] out[20]=sum_R[20] out[19]=sum_R[19]
+ out[18]=sum_R[18] out[17]=sum_R[17] out[16]=sum_R[16] out[15]=UNCONNECTED46
+ out[14]=UNCONNECTED45 out[13]=UNCONNECTED44 out[12]=UNCONNECTED43
+ out[11]=UNCONNECTED42 out[10]=UNCONNECTED41 out[9]=UNCONNECTED40
+ out[8]=UNCONNECTED39 out[7]=UNCONNECTED38 out[6]=UNCONNECTED37
+ out[5]=UNCONNECTED36 out[4]=UNCONNECTED35 out[3]=UNCONNECTED34
+ out[2]=UNCONNECTED33 out[1]=UNCONNECTED32 out[0]=UNCONNECTED31
Xalu_ctrl alu_controller $PINS Sclk=Sclk Clear=Clear en_FIR=data_enable
+ sleep_flag=sleep_flag rjdataL[15]=VSS rjdataL[14]=VSS rjdataL[13]=VSS
+ rjdataL[12]=VSS rjdataL[11]=VSS rjdataL[10]=VSS rjdataL[9]=VSS rjdataL[8]=VSS
+ rjdataL[7]=rjdataL[7] rjdataL[6]=rjdataL[6] rjdataL[5]=rjdataL[5]
+ rjdataL[4]=rjdataL[4] rjdataL[3]=rjdataL[3] rjdataL[2]=rjdataL[2]
+ rjdataL[1]=rjdataL[1] rjdataL[0]=rjdataL[0] coeffdataL[15]=VSS
+ coeffdataL[14]=VSS coeffdataL[13]=VSS coeffdataL[12]=VSS coeffdataL[11]=VSS
+ coeffdataL[10]=VSS coeffdataL[9]=VSS coeffdataL[8]=coeffdataL[8]
+ coeffdataL[7]=coeffdataL[7] coeffdataL[6]=coeffdataL[6]
+ coeffdataL[5]=coeffdataL[5] coeffdataL[4]=coeffdataL[4]
+ coeffdataL[3]=coeffdataL[3] coeffdataL[2]=coeffdataL[2]
+ coeffdataL[1]=coeffdataL[1] coeffdataL[0]=coeffdataL[0] indataL[15]=VSS
+ indataL[14]=VSS indataL[13]=VSS indataL[12]=VSS indataL[11]=VSS indataL[10]=VSS
+ indataL[9]=VSS indataL[8]=VSS indataL[7]=VSS indataL[6]=VSS indataL[5]=VSS
+ indataL[4]=VSS indataL[3]=VSS indataL[2]=VSS indataL[1]=VSS indataL[0]=VSS
+ rjdataR[15]=VSS rjdataR[14]=VSS rjdataR[13]=VSS rjdataR[12]=VSS rjdataR[11]=VSS
+ rjdataR[10]=VSS rjdataR[9]=VSS rjdataR[8]=VSS rjdataR[7]=rjdataR[7]
+ rjdataR[6]=rjdataR[6] rjdataR[5]=rjdataR[5] rjdataR[4]=rjdataR[4]
+ rjdataR[3]=rjdataR[3] rjdataR[2]=rjdataR[2] rjdataR[1]=rjdataR[1]
+ rjdataR[0]=rjdataR[0] coeffdataR[15]=VSS coeffdataR[14]=VSS coeffdataR[13]=VSS
+ coeffdataR[12]=VSS coeffdataR[11]=VSS coeffdataR[10]=VSS coeffdataR[9]=VSS
+ coeffdataR[8]=coeffdataR[8] coeffdataR[7]=coeffdataR[7]
+ coeffdataR[6]=coeffdataR[6] coeffdataR[5]=coeffdataR[5]
+ coeffdataR[4]=coeffdataR[4] coeffdataR[3]=coeffdataR[3]
+ coeffdataR[2]=coeffdataR[2] coeffdataR[1]=coeffdataR[1]
+ coeffdataR[0]=coeffdataR[0] indataR[15]=VSS indataR[14]=VSS indataR[13]=VSS
+ indataR[12]=VSS indataR[11]=VSS indataR[10]=VSS indataR[9]=VSS indataR[8]=VSS
+ indataR[7]=VSS indataR[6]=VSS indataR[5]=VSS indataR[4]=VSS indataR[3]=VSS
+ indataR[2]=VSS indataR[1]=VSS indataR[0]=VSS addL_input[39]=UNCONNECTED86
+ addL_input[38]=UNCONNECTED85 addL_input[37]=UNCONNECTED84
+ addL_input[36]=UNCONNECTED83 addL_input[35]=UNCONNECTED82
+ addL_input[34]=UNCONNECTED81 addL_input[33]=UNCONNECTED80
+ addL_input[32]=UNCONNECTED79 addL_input[31]=UNCONNECTED78
+ addL_input[30]=UNCONNECTED77 addL_input[29]=UNCONNECTED76
+ addL_input[28]=UNCONNECTED75 addL_input[27]=UNCONNECTED74
+ addL_input[26]=UNCONNECTED73 addL_input[25]=UNCONNECTED72
+ addL_input[24]=UNCONNECTED71 addL_input[23]=UNCONNECTED70
+ addL_input[22]=UNCONNECTED69 addL_input[21]=UNCONNECTED68
+ addL_input[20]=UNCONNECTED67 addL_input[19]=UNCONNECTED66
+ addL_input[18]=UNCONNECTED65 addL_input[17]=UNCONNECTED64
+ addL_input[16]=UNCONNECTED63 addL_input[15]=UNCONNECTED62
+ addL_input[14]=UNCONNECTED61 addL_input[13]=UNCONNECTED60
+ addL_input[12]=UNCONNECTED59 addL_input[11]=UNCONNECTED58
+ addL_input[10]=UNCONNECTED57 addL_input[9]=UNCONNECTED56
+ addL_input[8]=UNCONNECTED55 addL_input[7]=UNCONNECTED54
+ addL_input[6]=UNCONNECTED53 addL_input[5]=UNCONNECTED52
+ addL_input[4]=UNCONNECTED51 addL_input[3]=UNCONNECTED50
+ addL_input[2]=UNCONNECTED49 addL_input[1]=UNCONNECTED48
+ addL_input[0]=UNCONNECTED47 addR_input[39]=UNCONNECTED126
+ addR_input[38]=UNCONNECTED125 addR_input[37]=UNCONNECTED124
+ addR_input[36]=UNCONNECTED123 addR_input[35]=UNCONNECTED122
+ addR_input[34]=UNCONNECTED121 addR_input[33]=UNCONNECTED120
+ addR_input[32]=UNCONNECTED119 addR_input[31]=UNCONNECTED118
+ addR_input[30]=UNCONNECTED117 addR_input[29]=UNCONNECTED116
+ addR_input[28]=UNCONNECTED115 addR_input[27]=UNCONNECTED114
+ addR_input[26]=UNCONNECTED113 addR_input[25]=UNCONNECTED112
+ addR_input[24]=UNCONNECTED111 addR_input[23]=UNCONNECTED110
+ addR_input[22]=UNCONNECTED109 addR_input[21]=UNCONNECTED108
+ addR_input[20]=UNCONNECTED107 addR_input[19]=UNCONNECTED106
+ addR_input[18]=UNCONNECTED105 addR_input[17]=UNCONNECTED104
+ addR_input[16]=UNCONNECTED103 addR_input[15]=UNCONNECTED102
+ addR_input[14]=UNCONNECTED101 addR_input[13]=UNCONNECTED100
+ addR_input[12]=UNCONNECTED99 addR_input[11]=UNCONNECTED98
+ addR_input[10]=UNCONNECTED97 addR_input[9]=UNCONNECTED96
+ addR_input[8]=UNCONNECTED95 addR_input[7]=UNCONNECTED94
+ addR_input[6]=UNCONNECTED93 addR_input[5]=UNCONNECTED92
+ addR_input[4]=UNCONNECTED91 addR_input[3]=UNCONNECTED90
+ addR_input[2]=UNCONNECTED89 addR_input[1]=UNCONNECTED88
+ addR_input[0]=UNCONNECTED87 rjL_enable=rjL_enable coeffL_enable=UNCONNECTED127
+ inputL_enable=inputL_enable rjR_enable=rjR_enable coeffR_enable=UNCONNECTED128
+ inputR_enable=inputR_enable addsubL=addsubL adderL_en=adderL_en
+ shiftL_en=shiftL_en loadL=loadL clearL=clearL enable_PISO_L=en_PISO_L
+ addsubR=addsubR adderR_en=adderR_en shiftR_en=shiftR_en loadR=loadR
+ clearR=clearR enable_PISO_R=en_PISO_R rjL_addr[3]=rjL_addr[3]
+ rjL_addr[2]=rjL_addr[2] rjL_addr[1]=rjL_addr[1] rjL_addr[0]=rjL_addr[0]
+ coeffL_addr[8]=coeffL_addr[8] coeffL_addr[7]=coeffL_addr[7]
+ coeffL_addr[6]=coeffL_addr[6] coeffL_addr[5]=coeffL_addr[5]
+ coeffL_addr[4]=coeffL_addr[4] coeffL_addr[3]=coeffL_addr[3]
+ coeffL_addr[2]=coeffL_addr[2] coeffL_addr[1]=coeffL_addr[1]
+ coeffL_addr[0]=coeffL_addr[0] inputL_addr[7]=inputL_addr[7]
+ inputL_addr[6]=inputL_addr[6] inputL_addr[5]=inputL_addr[5]
+ inputL_addr[4]=inputL_addr[4] inputL_addr[3]=inputL_addr[3]
+ inputL_addr[2]=inputL_addr[2] inputL_addr[1]=inputL_addr[1]
+ inputL_addr[0]=inputL_addr[0] rjR_addr[3]=rjR_addr[3] rjR_addr[2]=rjR_addr[2]
+ rjR_addr[1]=rjR_addr[1] rjR_addr[0]=rjR_addr[0] coeffR_addr[8]=coeffR_addr[8]
+ coeffR_addr[7]=coeffR_addr[7] coeffR_addr[6]=coeffR_addr[6]
+ coeffR_addr[5]=coeffR_addr[5] coeffR_addr[4]=coeffR_addr[4]
+ coeffR_addr[3]=coeffR_addr[3] coeffR_addr[2]=coeffR_addr[2]
+ coeffR_addr[1]=coeffR_addr[1] coeffR_addr[0]=coeffR_addr[0]
+ inputR_addr[7]=inputR_addr[7] inputR_addr[6]=inputR_addr[6]
+ inputR_addr[5]=inputR_addr[5] inputR_addr[4]=inputR_addr[4]
+ inputR_addr[3]=inputR_addr[3] inputR_addr[2]=inputR_addr[2]
+ inputR_addr[1]=inputR_addr[1] inputR_addr[0]=inputR_addr[0]
Xmain_ctrl main_controller $PINS Sclk=Sclk Dclk=VSS Start=Start Reset_n=Reset_n
+ Frame=Frame input_ready=input_ready allzeros_L=flag_zeroL allzeros_R=flag_zeroR
+ Rj_Read_Address[3]=rjwrite[3] Rj_Read_Address[2]=rjwrite[2]
+ Rj_Read_Address[1]=rjwrite[1] Rj_Read_Address[0]=rjwrite[0]
+ Coefficient_Read_Address[8]=coeffwrite[8]
+ Coefficient_Read_Address[7]=coeffwrite[7]
+ Coefficient_Read_Address[6]=coeffwrite[6]
+ Coefficient_Read_Address[5]=coeffwrite[5]
+ Coefficient_Read_Address[4]=coeffwrite[4]
+ Coefficient_Read_Address[3]=coeffwrite[3]
+ Coefficient_Read_Address[2]=coeffwrite[2]
+ Coefficient_Read_Address[1]=coeffwrite[1]
+ Coefficient_Read_Address[0]=coeffwrite[0] Input_Read_Address[7]=datawrite[7]
+ Input_Read_Address[6]=datawrite[6] Input_Read_Address[5]=datawrite[5]
+ Input_Read_Address[4]=datawrite[4] Input_Read_Address[3]=datawrite[3]
+ Input_Read_Address[2]=datawrite[2] Input_Read_Address[1]=datawrite[1]
+ Input_Read_Address[0]=datawrite[0] en_FIR=data_enable sleep_flag=sleep_flag
+ InReady=InReady Rj_Read_Enable=rj_enable Coefficient_Read_Enable=coeff_enable
+ Data_Read_Enable=UNCONNECTED129 Clear=Clear Frame_out=UNCONNECTED130
+ Dclk_out=UNCONNECTED131 Sclk_out=UNCONNECTED132
Xpipo PIPO $PINS Frame=Frame Dclk=Dclk Clear=Clear InputL[15]=InputL[15]
+ InputL[14]=InputL[14] InputL[13]=InputL[13] InputL[12]=InputL[12]
+ InputL[11]=InputL[11] InputL[10]=InputL[10] InputL[9]=InputL[9]
+ InputL[8]=InputL[8] InputL[7]=InputL[7] InputL[6]=InputL[6] InputL[5]=InputL[5]
+ InputL[4]=InputL[4] InputL[3]=InputL[3] InputL[2]=InputL[2] InputL[1]=InputL[1]
+ InputL[0]=InputL[0] InputR[15]=InputR[15] InputR[14]=InputR[14]
+ InputR[13]=InputR[13] InputR[12]=InputR[12] InputR[11]=InputR[11]
+ InputR[10]=InputR[10] InputR[9]=InputR[9] InputR[8]=InputR[8]
+ InputR[7]=InputR[7] InputR[6]=InputR[6] InputR[5]=InputR[5] InputR[4]=InputR[4]
+ InputR[3]=InputR[3] InputR[2]=InputR[2] InputR[1]=InputR[1] InputR[0]=InputR[0]
+ dataL[15]=dataL[15] dataL[14]=dataL[14] dataL[13]=dataL[13] dataL[12]=dataL[12]
+ dataL[11]=dataL[11] dataL[10]=dataL[10] dataL[9]=dataL[9] dataL[8]=dataL[8]
+ dataL[7]=dataL[7] dataL[6]=dataL[6] dataL[5]=dataL[5] dataL[4]=dataL[4]
+ dataL[3]=dataL[3] dataL[2]=dataL[2] dataL[1]=dataL[1] dataL[0]=dataL[0]
+ dataR[15]=dataR[15] dataR[14]=dataR[14] dataR[13]=dataR[13] dataR[12]=dataR[12]
+ dataR[11]=dataR[11] dataR[10]=dataR[10] dataR[9]=dataR[9] dataR[8]=dataR[8]
+ dataR[7]=dataR[7] dataR[6]=dataR[6] dataR[5]=dataR[5] dataR[4]=dataR[4]
+ dataR[3]=dataR[3] dataR[2]=dataR[2] dataR[1]=dataR[1] dataR[0]=dataR[0]
+ input_ready=input_ready
XshiftL shifter $PINS shift_en=shiftL_en load=loadL clear=clearL sclk=Sclk
+ inputdata[39]=sum_L[39] inputdata[38]=sum_L[38] inputdata[37]=sum_L[37]
+ inputdata[36]=sum_L[36] inputdata[35]=sum_L[35] inputdata[34]=sum_L[34]
+ inputdata[33]=sum_L[33] inputdata[32]=sum_L[32] inputdata[31]=sum_L[31]
+ inputdata[30]=sum_L[30] inputdata[29]=sum_L[29] inputdata[28]=sum_L[28]
+ inputdata[27]=sum_L[27] inputdata[26]=sum_L[26] inputdata[25]=sum_L[25]
+ inputdata[24]=sum_L[24] inputdata[23]=sum_L[23] inputdata[22]=sum_L[22]
+ inputdata[21]=sum_L[21] inputdata[20]=sum_L[20] inputdata[19]=sum_L[19]
+ inputdata[18]=sum_L[18] inputdata[17]=sum_L[17] inputdata[16]=sum_L[16]
+ inputdata[15]=VSS inputdata[14]=VSS inputdata[13]=VSS inputdata[12]=VSS
+ inputdata[11]=VSS inputdata[10]=VSS inputdata[9]=VSS inputdata[8]=VSS
+ inputdata[7]=VSS inputdata[6]=VSS inputdata[5]=VSS inputdata[4]=VSS
+ inputdata[3]=VSS inputdata[2]=VSS inputdata[1]=VSS inputdata[0]=VSS
+ outputdata[39]=Shift_done_L[39] outputdata[38]=Shift_done_L[38]
+ outputdata[37]=Shift_done_L[37] outputdata[36]=Shift_done_L[36]
+ outputdata[35]=Shift_done_L[35] outputdata[34]=Shift_done_L[34]
+ outputdata[33]=Shift_done_L[33] outputdata[32]=Shift_done_L[32]
+ outputdata[31]=Shift_done_L[31] outputdata[30]=Shift_done_L[30]
+ outputdata[29]=Shift_done_L[29] outputdata[28]=Shift_done_L[28]
+ outputdata[27]=Shift_done_L[27] outputdata[26]=Shift_done_L[26]
+ outputdata[25]=Shift_done_L[25] outputdata[24]=Shift_done_L[24]
+ outputdata[23]=Shift_done_L[23] outputdata[22]=Shift_done_L[22]
+ outputdata[21]=Shift_done_L[21] outputdata[20]=Shift_done_L[20]
+ outputdata[19]=Shift_done_L[19] outputdata[18]=Shift_done_L[18]
+ outputdata[17]=Shift_done_L[17] outputdata[16]=Shift_done_L[16]
+ outputdata[15]=Shift_done_L[15] outputdata[14]=Shift_done_L[14]
+ outputdata[13]=Shift_done_L[13] outputdata[12]=Shift_done_L[12]
+ outputdata[11]=Shift_done_L[11] outputdata[10]=Shift_done_L[10]
+ outputdata[9]=Shift_done_L[9] outputdata[8]=Shift_done_L[8]
+ outputdata[7]=Shift_done_L[7] outputdata[6]=Shift_done_L[6]
+ outputdata[5]=Shift_done_L[5] outputdata[4]=Shift_done_L[4]
+ outputdata[3]=Shift_done_L[3] outputdata[2]=Shift_done_L[2]
+ outputdata[1]=Shift_done_L[1] outputdata[0]=Shift_done_L[0]
XshiftR shifter_1 $PINS shift_en=shiftR_en load=loadR clear=clearR sclk=Sclk
+ inputdata[39]=sum_R[39] inputdata[38]=sum_R[38] inputdata[37]=sum_R[37]
+ inputdata[36]=sum_R[36] inputdata[35]=sum_R[35] inputdata[34]=sum_R[34]
+ inputdata[33]=sum_R[33] inputdata[32]=sum_R[32] inputdata[31]=sum_R[31]
+ inputdata[30]=sum_R[30] inputdata[29]=sum_R[29] inputdata[28]=sum_R[28]
+ inputdata[27]=sum_R[27] inputdata[26]=sum_R[26] inputdata[25]=sum_R[25]
+ inputdata[24]=sum_R[24] inputdata[23]=sum_R[23] inputdata[22]=sum_R[22]
+ inputdata[21]=sum_R[21] inputdata[20]=sum_R[20] inputdata[19]=sum_R[19]
+ inputdata[18]=sum_R[18] inputdata[17]=sum_R[17] inputdata[16]=sum_R[16]
+ inputdata[15]=VSS inputdata[14]=VSS inputdata[13]=VSS inputdata[12]=VSS
+ inputdata[11]=VSS inputdata[10]=VSS inputdata[9]=VSS inputdata[8]=VSS
+ inputdata[7]=VSS inputdata[6]=VSS inputdata[5]=VSS inputdata[4]=VSS
+ inputdata[3]=VSS inputdata[2]=VSS inputdata[1]=VSS inputdata[0]=VSS
+ outputdata[39]=Shift_done_R[39] outputdata[38]=Shift_done_R[38]
+ outputdata[37]=Shift_done_R[37] outputdata[36]=Shift_done_R[36]
+ outputdata[35]=Shift_done_R[35] outputdata[34]=Shift_done_R[34]
+ outputdata[33]=Shift_done_R[33] outputdata[32]=Shift_done_R[32]
+ outputdata[31]=Shift_done_R[31] outputdata[30]=Shift_done_R[30]
+ outputdata[29]=Shift_done_R[29] outputdata[28]=Shift_done_R[28]
+ outputdata[27]=Shift_done_R[27] outputdata[26]=Shift_done_R[26]
+ outputdata[25]=Shift_done_R[25] outputdata[24]=Shift_done_R[24]
+ outputdata[23]=Shift_done_R[23] outputdata[22]=Shift_done_R[22]
+ outputdata[21]=Shift_done_R[21] outputdata[20]=Shift_done_R[20]
+ outputdata[19]=Shift_done_R[19] outputdata[18]=Shift_done_R[18]
+ outputdata[17]=Shift_done_R[17] outputdata[16]=Shift_done_R[16]
+ outputdata[15]=Shift_done_R[15] outputdata[14]=Shift_done_R[14]
+ outputdata[13]=Shift_done_R[13] outputdata[12]=Shift_done_R[12]
+ outputdata[11]=Shift_done_R[11] outputdata[10]=Shift_done_R[10]
+ outputdata[9]=Shift_done_R[9] outputdata[8]=Shift_done_R[8]
+ outputdata[7]=Shift_done_R[7] outputdata[6]=Shift_done_R[6]
+ outputdata[5]=Shift_done_R[5] outputdata[4]=Shift_done_R[4]
+ outputdata[3]=Shift_done_R[3] outputdata[2]=Shift_done_R[2]
+ outputdata[1]=Shift_done_R[1] outputdata[0]=Shift_done_R[0]
Xg11 AND2x2_ASAP7_75t_R $PINS A=OutReadyR B=OutReadyL Y=OutReady
.ENDS
.GLOBAL VDD
.GLOBAL VSS
